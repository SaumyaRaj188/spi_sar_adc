* NGSPICE file created from spi_adc.ext - technology: sky130A

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_4 abstract view
.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_8 abstract view
.subckt sky130_fd_sc_hd__ebufn_8 A TE_B VGND VNB VPB VPWR Z
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_2 abstract view
.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_2 abstract view
.subckt sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

.subckt spi_adc VGND VPWR adc_clk_out comparator cs dac[0] dac[10] dac[11] dac[1]
+ dac[2] dac[3] dac[4] dac[5] dac[6] dac[7] dac[8] dac[9] dac_rst irq miso mosi pwr_gate
+ reset_ sample_and_hold sck sys_clk vref_sel
XFILLER_22_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_432_ u_spi.miso_buffer\[7\] net31 _205_ VGND VGND VPWR VPWR _230_ sky130_fd_sc_hd__o21a_1
X_501_ adc_data_out\[8\] _254_ net24 VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__mux2_1
X_363_ u_controller.counter_reg\[3\] net35 u_controller.dac_reg\[3\] VGND VGND VPWR
+ VPWR net12 sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_23_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_294_ u_spi.pay\[10\] VGND VGND VPWR VPWR _146_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_29_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_415_ net97 net32 _217_ VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__o21a_1
XFILLER_33_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_346_ _172_ _175_ _176_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__and3_1
XFILLER_24_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_606__70 VGND VGND VPWR VPWR _606__70/HI net70 sky130_fd_sc_hd__conb_1
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_329_ clk_cnt\[4\] clk_cnt\[5\] VGND VGND VPWR VPWR _162_ sky130_fd_sc_hd__or2_1
X_603__73 VGND VGND VPWR VPWR _603__73/HI net73 sky130_fd_sc_hd__conb_1
X_680_ clknet_3_2__leaf_sys_clk _039_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_600__76 VGND VGND VPWR VPWR _600__76/HI net76 sky130_fd_sc_hd__conb_1
Xhold41 u_spi.bit_cnt\[3\] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 u_spi.data_reg\[1\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
X_663_ clknet_3_1__leaf_sys_clk _117_ net53 VGND VGND VPWR VPWR u_spi.addr\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_594_ clknet_3_5__leaf_sys_clk net82 net60 VGND VGND VPWR VPWR clk_cnt\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput20 net20 VGND VGND VPWR VPWR irq sky130_fd_sc_hd__buf_2
Xoutput7 net7 VGND VGND VPWR VPWR dac[0] sky130_fd_sc_hd__buf_2
XFILLER_31_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_577_ clknet_3_2__leaf_sys_clk net89 net55 VGND VGND VPWR VPWR u_spi.eoc_s2 sky130_fd_sc_hd__dfrtp_1
XFILLER_16_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_646_ net49 _101_ net43 VGND VGND VPWR VPWR adc_data_out\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_500_ adc_data_out\[7\] _253_ net24 VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__mux2_1
X_362_ u_controller.counter_reg\[2\] net35 u_controller.dac_reg\[2\] VGND VGND VPWR
+ VPWR net11 sky130_fd_sc_hd__a21o_1
X_431_ net100 net32 _227_ _229_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__o22a_1
XFILLER_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_293_ u_spi.pay\[9\] VGND VGND VPWR VPWR _145_ sky130_fd_sc_hd__inv_2
X_629_ net48 _084_ net42 VGND VGND VPWR VPWR u_controller.counter_reg\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_414_ net26 _215_ _216_ net27 VGND VGND VPWR VPWR _217_ sky130_fd_sc_hd__a22o_1
X_345_ clk_cnt\[1\] clk_cnt\[0\] clk_cnt\[2\] VGND VGND VPWR VPWR _176_ sky130_fd_sc_hd__a21o_1
XFILLER_24_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_328_ clk_cnt\[5\] clk_cnt\[6\] clk_cnt\[7\] VGND VGND VPWR VPWR _161_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_0_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold20 u_spi.bit_cnt\[2\] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 bit_int_en VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
X_662_ clknet_3_4__leaf_sys_clk _116_ net57 VGND VGND VPWR VPWR u_spi.pay\[11\] sky130_fd_sc_hd__dfrtp_1
Xhold31 ctrl_reg\[11\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
X_593_ clknet_3_5__leaf_sys_clk net83 net60 VGND VGND VPWR VPWR clk_cnt\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_195 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_7__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_7__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_25_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput21 net21 VGND VGND VPWR VPWR pwr_gate sky130_fd_sc_hd__buf_2
XFILLER_0_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput10 net10 VGND VGND VPWR VPWR dac[1] sky130_fd_sc_hd__buf_2
Xoutput8 net8 VGND VGND VPWR VPWR dac[10] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_33_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_645_ net49 _100_ net44 VGND VGND VPWR VPWR adc_data_out\[7\] sky130_fd_sc_hd__dfrtp_1
X_576_ net47 _066_ net41 VGND VGND VPWR VPWR u_controller.state\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_361_ u_controller.counter_reg\[1\] net35 u_controller.dac_reg\[1\] VGND VGND VPWR
+ VPWR net10 sky130_fd_sc_hd__a21o_1
X_430_ net27 _228_ VGND VGND VPWR VPWR _229_ sky130_fd_sc_hd__and2_1
X_292_ u_spi.pay\[8\] VGND VGND VPWR VPWR _144_ sky130_fd_sc_hd__inv_2
XFILLER_26_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_628_ net48 _083_ net42 VGND VGND VPWR VPWR u_controller.counter_reg\[2\] sky130_fd_sc_hd__dfrtp_1
X_559_ clknet_3_4__leaf_sys_clk _049_ net57 VGND VGND VPWR VPWR ctrl_reg\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_413_ u_spi.pay\[1\] net23 _198_ u_spi.data_reg\[3\] _207_ VGND VGND VPWR VPWR _216_
+ sky130_fd_sc_hd__o221a_1
X_344_ clk_cnt\[1\] clk_cnt\[0\] clk_cnt\[2\] VGND VGND VPWR VPWR _175_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_20_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_327_ clk_cnt\[1\] clk_cnt\[3\] clk_cnt\[2\] _159_ VGND VGND VPWR VPWR _160_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_0_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold10 u_spi.miso_buffer\[4\] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 _132_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 _052_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 ctrl_reg\[7\] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
X_661_ clknet_3_4__leaf_sys_clk _115_ net57 VGND VGND VPWR VPWR u_spi.pay\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_592_ clknet_3_5__leaf_sys_clk net84 net60 VGND VGND VPWR VPWR clk_cnt\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_15_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput11 net11 VGND VGND VPWR VPWR dac[2] sky130_fd_sc_hd__buf_2
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput9 net9 VGND VGND VPWR VPWR dac[11] sky130_fd_sc_hd__buf_2
Xoutput22 net22 VGND VGND VPWR VPWR sample_and_hold sky130_fd_sc_hd__buf_2
X_575_ net47 _065_ net41 VGND VGND VPWR VPWR u_controller.state\[0\] sky130_fd_sc_hd__dfrtp_2
X_644_ net51 _099_ net44 VGND VGND VPWR VPWR adc_data_out\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_360_ u_controller.counter_reg\[0\] net35 u_controller.dac_reg\[0\] VGND VGND VPWR
+ VPWR net7 sky130_fd_sc_hd__a21o_1
X_291_ u_spi.pay\[7\] VGND VGND VPWR VPWR _143_ sky130_fd_sc_hd__inv_2
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_627_ net48 _082_ net41 VGND VGND VPWR VPWR u_controller.counter_reg\[1\] sky130_fd_sc_hd__dfrtp_1
X_558_ clknet_3_6__leaf_sys_clk _048_ net57 VGND VGND VPWR VPWR ctrl_reg\[7\] sky130_fd_sc_hd__dfrtp_1
X_489_ u_controller.counter_reg\[10\] net37 net25 u_controller.counter_reg\[9\] VGND
+ VGND VPWR VPWR _090_ sky130_fd_sc_hd__a22o_1
XFILLER_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_412_ u_spi.miso_buffer\[2\] net31 VGND VGND VPWR VPWR _215_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_11_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_343_ _172_ _173_ _174_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__and3_1
XFILLER_32_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_326_ bit_clk_sel clk_cnt\[5\] clk_cnt\[7\] clk_cnt\[4\] VGND VGND VPWR VPWR _159_
+ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_0_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_309_ adc_data_out\[2\] net111 net34 VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__mux2_1
XFILLER_37_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold22 u_spi.data_reg\[6\] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 u_spi.miso_buffer\[9\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dlygate4sd3_1
X_660_ clknet_3_4__leaf_sys_clk _114_ net57 VGND VGND VPWR VPWR u_spi.pay\[9\] sky130_fd_sc_hd__dfrtp_1
Xhold33 ctrl_reg\[9\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_591_ clknet_3_5__leaf_sys_clk net85 net60 VGND VGND VPWR VPWR clk_cnt\[11\] sky130_fd_sc_hd__dfrtp_1
Xhold44 u_spi.data_reg\[11\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput23 net23 VGND VGND VPWR VPWR vref_sel sky130_fd_sc_hd__buf_2
Xoutput12 net12 VGND VGND VPWR VPWR dac[3] sky130_fd_sc_hd__buf_2
X_643_ net51 _098_ net44 VGND VGND VPWR VPWR adc_data_out\[5\] sky130_fd_sc_hd__dfrtp_1
X_574_ clknet_3_6__leaf_sys_clk _064_ net62 VGND VGND VPWR VPWR u_spi.miso_buffer\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_290_ u_spi.pay\[6\] VGND VGND VPWR VPWR _142_ sky130_fd_sc_hd__inv_2
XFILLER_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_626_ net47 _081_ net41 VGND VGND VPWR VPWR u_controller.counter_reg\[0\] sky130_fd_sc_hd__dfrtp_1
X_488_ u_controller.counter_reg\[9\] net37 _150_ u_controller.counter_reg\[8\] VGND
+ VGND VPWR VPWR _089_ sky130_fd_sc_hd__a22o_1
X_557_ clknet_3_4__leaf_sys_clk _047_ net57 VGND VGND VPWR VPWR bit_clk_sel sky130_fd_sc_hd__dfrtp_1
XFILLER_35_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_342_ clk_cnt\[1\] clk_cnt\[0\] VGND VGND VPWR VPWR _174_ sky130_fd_sc_hd__nand2_1
X_411_ net95 net32 _212_ _214_ VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__o22a_1
XFILLER_5_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_609_ clknet_3_4__leaf_sys_clk net67 net58 VGND VGND VPWR VPWR clk_cnt\[29\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_325_ bit_start bit_auto net21 net93 VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__o31ai_1
XFILLER_14_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload0 clknet_3_0__leaf_sys_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__inv_6
X_308_ adc_data_out\[1\] net118 net34 VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__mux2_1
XFILLER_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold23 u_spi.data_reg\[2\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 u_spi.state\[1\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 u_spi.miso_buffer\[7\] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 _050_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
X_590_ clknet_3_5__leaf_sys_clk net86 net60 VGND VGND VPWR VPWR clk_cnt\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput13 net13 VGND VGND VPWR VPWR dac[4] sky130_fd_sc_hd__buf_2
X_642_ net51 _097_ net42 VGND VGND VPWR VPWR adc_data_out\[4\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_573_ clknet_3_6__leaf_sys_clk _063_ net62 VGND VGND VPWR VPWR u_spi.miso_buffer\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_625_ net50 _080_ net43 VGND VGND VPWR VPWR u_controller.dac_reg\[11\] sky130_fd_sc_hd__dfrtp_1
X_556_ net2 VGND VGND VPWR VPWR _281_ sky130_fd_sc_hd__buf_1
X_487_ u_controller.counter_reg\[8\] net38 _150_ u_controller.counter_reg\[7\] VGND
+ VGND VPWR VPWR _088_ sky130_fd_sc_hd__a22o_1
Xclkbuf_3_6__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_6__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_341_ clk_cnt\[1\] clk_cnt\[0\] VGND VGND VPWR VPWR _173_ sky130_fd_sc_hd__or2_1
X_410_ net27 _213_ VGND VGND VPWR VPWR _214_ sky130_fd_sc_hd__and2_1
XFILLER_26_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_608_ clknet_3_5__leaf_sys_clk net68 net58 VGND VGND VPWR VPWR clk_cnt\[28\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_34_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_539_ net106 _271_ _127_ VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_324_ bit_start _157_ _158_ net28 u_spi.pay\[1\] VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_24_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload1 clknet_3_1__leaf_sys_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__inv_8
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_307_ adc_data_out\[0\] net124 net34 VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__mux2_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold46 eoc_flag VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 u_spi.data_reg\[3\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 u_spi.miso_buffer\[6\] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 ctrl_reg\[10\] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_588__88 VGND VGND VPWR VPWR _588__88/HI net88 sky130_fd_sc_hd__conb_1
XFILLER_19_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_27_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput14 net14 VGND VGND VPWR VPWR dac[5] sky130_fd_sc_hd__buf_2
X_641_ net51 _096_ net42 VGND VGND VPWR VPWR adc_data_out\[3\] sky130_fd_sc_hd__dfrtp_1
X_572_ clknet_3_6__leaf_sys_clk _062_ net62 VGND VGND VPWR VPWR u_spi.miso_buffer\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_555_ u_spi.pay\[5\] net28 _280_ net103 VGND VGND VPWR VPWR _133_ sky130_fd_sc_hd__a22o_1
X_624_ net50 _079_ net43 VGND VGND VPWR VPWR u_controller.dac_reg\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_486_ u_controller.counter_reg\[7\] net38 _150_ u_controller.counter_reg\[6\] VGND
+ VGND VPWR VPWR _087_ sky130_fd_sc_hd__a22o_1
XFILLER_10_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_340_ clk_cnt\[0\] _172_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_11_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_538_ _260_ _269_ _262_ VGND VGND VPWR VPWR _271_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_34_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_607_ clknet_3_5__leaf_sys_clk net69 net59 VGND VGND VPWR VPWR clk_cnt\[27\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_469_ u_controller.dac_reg\[6\] net38 _252_ net39 VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__o211a_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout60 net63 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_4
X_323_ start_clear_req net33 VGND VGND VPWR VPWR _158_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_30_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload2 clknet_3_2__leaf_sys_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__inv_8
X_306_ start_clear_req _152_ _151_ VGND VGND VPWR VPWR _153_ sky130_fd_sc_hd__mux2_2
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold36 u_spi.data_reg\[0\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 bit_start VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 u_spi.miso_buffer\[5\] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold25 u_spi.data_reg\[10\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_159 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput15 net15 VGND VGND VPWR VPWR dac[6] sky130_fd_sc_hd__buf_2
X_640_ net47 _095_ net41 VGND VGND VPWR VPWR adc_data_out\[2\] sky130_fd_sc_hd__dfrtp_1
X_571_ clknet_3_6__leaf_sys_clk _061_ net62 VGND VGND VPWR VPWR u_spi.miso_buffer\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_485_ u_controller.counter_reg\[6\] net36 net25 u_controller.counter_reg\[5\] VGND
+ VGND VPWR VPWR _086_ sky130_fd_sc_hd__a22o_1
X_554_ net46 _141_ _155_ VGND VGND VPWR VPWR _280_ sky130_fd_sc_hd__a21o_1
XFILLER_29_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_623_ net49 _078_ net43 VGND VGND VPWR VPWR u_controller.dac_reg\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_12_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_147 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_537_ net2 net133 _270_ VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__nor3_1
X_468_ u_controller.counter_reg\[6\] net64 u_controller.dac_reg\[6\] VGND VGND VPWR
+ VPWR _252_ sky130_fd_sc_hd__a21o_1
X_606_ clknet_3_5__leaf_sys_clk net70 net59 VGND VGND VPWR VPWR clk_cnt\[26\] sky130_fd_sc_hd__dfrtp_1
X_399_ _192_ _203_ VGND VGND VPWR VPWR _205_ sky130_fd_sc_hd__or2_2
XFILLER_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_322_ _135_ net45 net33 VGND VGND VPWR VPWR _157_ sky130_fd_sc_hd__a21o_1
Xfanout50 net51 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_2
Xfanout61 net62 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_30_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload3 clknet_3_3__leaf_sys_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__inv_8
X_305_ u_spi.state\[0\] u_spi.state\[1\] VGND VGND VPWR VPWR _152_ sky130_fd_sc_hd__or2_1
X_597__79 VGND VGND VPWR VPWR _597__79/HI net79 sky130_fd_sc_hd__conb_1
XFILLER_37_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold48 bit_auto VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 ctrl_reg\[5\] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 u_spi.data_reg\[8\] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 u_spi.data_reg\[9\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput16 net16 VGND VGND VPWR VPWR dac[7] sky130_fd_sc_hd__buf_2
X_570_ clknet_3_6__leaf_sys_clk _060_ net62 VGND VGND VPWR VPWR u_spi.miso_buffer\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_21_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_622_ net49 _077_ net44 VGND VGND VPWR VPWR u_controller.dac_reg\[8\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_484_ u_controller.counter_reg\[5\] net36 net25 u_controller.counter_reg\[4\] VGND
+ VGND VPWR VPWR _085_ sky130_fd_sc_hd__a22o_1
X_553_ u_spi.pay\[4\] net28 _279_ net130 VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__a22o_1
XFILLER_12_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_605_ clknet_3_5__leaf_sys_clk net71 net59 VGND VGND VPWR VPWR clk_cnt\[25\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_398_ _203_ VGND VGND VPWR VPWR _204_ sky130_fd_sc_hd__inv_2
X_536_ u_spi.sck_s2 u_spi.bit_cnt\[4\] _259_ _269_ VGND VGND VPWR VPWR _270_ sky130_fd_sc_hd__or4_1
X_467_ u_controller.dac_reg\[5\] _149_ _251_ net39 VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__o211a_1
XFILLER_4_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_5__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_5__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
Xfanout51 net6 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_2
Xfanout62 net63 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_4
Xfanout40 _195_ VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_2
X_321_ u_spi.cmd\[0\] net45 net33 VGND VGND VPWR VPWR _156_ sky130_fd_sc_hd__a21oi_1
XFILLER_14_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_519_ u_spi.pay\[10\] u_spi.pay\[11\] net29 VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_30_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload4 clknet_3_4__leaf_sys_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinv_4
X_304_ u_spi.eoc_s2 u_spi.eoc_s1 VGND VGND VPWR VPWR _151_ sky130_fd_sc_hd__nand2b_1
XFILLER_24_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold38 u_spi.eoc_sent_high VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 _133_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 u_spi.data_reg\[7\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_596__80 VGND VGND VPWR VPWR _596__80/HI net80 sky130_fd_sc_hd__conb_1
Xhold49 u_spi.bit_cnt\[1\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_593__83 VGND VGND VPWR VPWR _593__83/HI net83 sky130_fd_sc_hd__conb_1
Xoutput17 net17 VGND VGND VPWR VPWR dac[8] sky130_fd_sc_hd__buf_2
XFILLER_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_590__86 VGND VGND VPWR VPWR _590__86/HI net86 sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_15_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_621_ net49 _076_ net44 VGND VGND VPWR VPWR u_controller.dac_reg\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_12_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_483_ u_controller.counter_reg\[4\] net36 net25 u_controller.counter_reg\[3\] VGND
+ VGND VPWR VPWR _084_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_14_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_552_ net45 _140_ net33 VGND VGND VPWR VPWR _279_ sky130_fd_sc_hd__a21o_1
XFILLER_8_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_604_ clknet_3_5__leaf_sys_clk net72 net59 VGND VGND VPWR VPWR clk_cnt\[24\] sky130_fd_sc_hd__dfrtp_1
X_535_ u_spi.bit_cnt\[3\] _265_ VGND VGND VPWR VPWR _269_ sky130_fd_sc_hd__nand2_1
XFILLER_17_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_397_ u_spi.pay\[3\] u_spi.pay\[2\] _201_ _202_ VGND VGND VPWR VPWR _203_ sky130_fd_sc_hd__or4_1
X_466_ u_controller.counter_reg\[5\] net64 u_controller.dac_reg\[5\] VGND VGND VPWR
+ VPWR _251_ sky130_fd_sc_hd__a21o_1
XFILLER_4_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_18_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout63 net4 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_2
Xfanout41 net42 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_4
Xfanout52 net54 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_4
X_320_ u_spi.cmd\[0\] net45 _154_ VGND VGND VPWR VPWR _155_ sky130_fd_sc_hd__o21bai_4
Xfanout30 _261_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_0_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_518_ u_spi.pay\[9\] u_spi.pay\[10\] net30 VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__mux2_1
X_449_ u_controller.counter_reg\[5\] u_controller.counter_reg\[4\] u_controller.counter_reg\[7\]
+ u_controller.counter_reg\[6\] VGND VGND VPWR VPWR _243_ sky130_fd_sc_hd__or4_1
XFILLER_20_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload5 clknet_3_6__leaf_sys_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__inv_8
XPHY_EDGE_ROW_3_Left_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_303_ bit_en net55 VGND VGND VPWR VPWR u_controller.reset_ sky130_fd_sc_hd__and2_1
XFILLER_40_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold39 _067_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 u_spi.data_reg\[4\] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 u_spi.miso_buffer\[10\] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput18 net18 VGND VGND VPWR VPWR dac[9] sky130_fd_sc_hd__buf_2
XFILLER_21_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_551_ u_spi.pay\[3\] net28 _278_ net23 VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__a22o_1
X_620_ net48 _075_ net44 VGND VGND VPWR VPWR u_controller.dac_reg\[6\] sky130_fd_sc_hd__dfrtp_1
X_482_ u_controller.counter_reg\[3\] net36 net25 u_controller.counter_reg\[2\] VGND
+ VGND VPWR VPWR _083_ sky130_fd_sc_hd__a22o_1
XFILLER_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_534_ net129 _266_ _268_ VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__a21bo_1
X_465_ u_controller.dac_reg\[4\] net36 _250_ net39 VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__o211a_1
X_603_ clknet_3_4__leaf_sys_clk net73 net58 VGND VGND VPWR VPWR clk_cnt\[23\] sky130_fd_sc_hd__dfrtp_1
X_396_ u_spi.sck_s1 u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] u_spi.sck_s2 VGND VGND VPWR
+ VPWR _202_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_10_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout31 _194_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_2
Xfanout42 u_controller.reset_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_4
Xfanout53 net54 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_4
Xfanout64 net1 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_517_ u_spi.pay\[8\] u_spi.pay\[9\] net30 VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__mux2_1
X_448_ u_controller.counter_reg\[9\] u_controller.counter_reg\[8\] u_controller.counter_reg\[11\]
+ u_controller.counter_reg\[10\] VGND VGND VPWR VPWR _242_ sky130_fd_sc_hd__or4_1
X_379_ net45 _145_ net33 VGND VGND VPWR VPWR _188_ sky130_fd_sc_hd__a21o_1
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkload6 clknet_3_7__leaf_sys_clk VGND VGND VPWR VPWR clkload6/Y sky130_fd_sc_hd__inv_6
X_302_ u_controller.state\[0\] u_controller.state\[1\] net135 VGND VGND VPWR VPWR
+ _033_ sky130_fd_sc_hd__o21a_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold18 u_spi.bit_cnt\[4\] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 u_spi.data_reg\[5\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_10_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput19 net19 VGND VGND VPWR VPWR dac_rst sky130_fd_sc_hd__buf_2
XFILLER_16_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_481_ u_controller.counter_reg\[2\] net35 net25 u_controller.counter_reg\[1\] VGND
+ VGND VPWR VPWR _082_ sky130_fd_sc_hd__a22o_1
XFILLER_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_550_ _136_ net45 net33 VGND VGND VPWR VPWR _278_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_679_ clknet_3_2__leaf_sys_clk _038_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_609__67 VGND VGND VPWR VPWR _609__67/HI net67 sky130_fd_sc_hd__conb_1
X_602_ clknet_3_5__leaf_sys_clk net74 net58 VGND VGND VPWR VPWR clk_cnt\[22\] sky130_fd_sc_hd__dfrtp_1
X_533_ u_spi.bit_cnt\[3\] net29 _265_ VGND VGND VPWR VPWR _268_ sky130_fd_sc_hd__or3b_1
X_464_ u_controller.counter_reg\[4\] net64 u_controller.dac_reg\[4\] VGND VGND VPWR
+ VPWR _250_ sky130_fd_sc_hd__a21o_1
X_395_ net2 u_spi.bit_cnt\[3\] u_spi.bit_cnt\[4\] u_spi.bit_cnt\[2\] VGND VGND VPWR
+ VPWR _201_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_10_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout32 _193_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_2
Xfanout54 net4 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_2
Xfanout43 net44 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_447_ net138 net32 _239_ _241_ VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__o22a_1
X_516_ u_spi.pay\[7\] u_spi.pay\[8\] net30 VGND VGND VPWR VPWR _113_ sky130_fd_sc_hd__mux2_1
X_378_ u_spi.pay\[8\] net28 _187_ net128 VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__a22o_1
X_301_ net25 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__inv_2
Xclkbuf_3_4__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_4__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
Xhold19 u_spi.miso_buffer\[8\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_480_ u_controller.counter_reg\[1\] net35 net25 u_controller.counter_reg\[0\] VGND
+ VGND VPWR VPWR _081_ sky130_fd_sc_hd__a22o_1
XFILLER_8_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_678_ clknet_3_2__leaf_sys_clk _035_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_601_ clknet_3_4__leaf_sys_clk net75 net60 VGND VGND VPWR VPWR clk_cnt\[21\] sky130_fd_sc_hd__dfrtp_1
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_394_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] VGND VGND VPWR VPWR _200_ sky130_fd_sc_hd__or2_1
X_532_ net108 _267_ _266_ VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__o21a_1
X_463_ u_controller.dac_reg\[3\] net36 _249_ net39 VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__o211a_1
XFILLER_32_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout55 net4 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
Xfanout33 _155_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_4
Xfanout44 u_controller.reset_ VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_4
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_605__71 VGND VGND VPWR VPWR _605__71/HI net71 sky130_fd_sc_hd__conb_1
X_515_ u_spi.pay\[6\] u_spi.pay\[7\] net30 VGND VGND VPWR VPWR _112_ sky130_fd_sc_hd__mux2_1
XFILLER_13_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_446_ net27 _240_ VGND VGND VPWR VPWR _241_ sky130_fd_sc_hd__and2_1
X_377_ net46 _144_ _155_ VGND VGND VPWR VPWR _187_ sky130_fd_sc_hd__a21o_1
X_602__74 VGND VGND VPWR VPWR _602__74/HI net74 sky130_fd_sc_hd__conb_1
XFILLER_39_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_300_ net19 net37 VGND VGND VPWR VPWR _150_ sky130_fd_sc_hd__nor2_1
XFILLER_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_429_ ctrl_reg\[7\] net40 _197_ u_spi.data_reg\[7\] VGND VGND VPWR VPWR _228_ sky130_fd_sc_hd__a22o_1
Xinput1 comparator VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
XFILLER_19_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_694_ clknet_3_3__leaf_sys_clk net104 net56 VGND VGND VPWR VPWR ctrl_reg\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_15_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_677_ clknet_3_2__leaf_sys_clk adc_ack net55 VGND VGND VPWR VPWR u_spi.eoc_s1 sky130_fd_sc_hd__dfrtp_1
XFILLER_35_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_531_ _262_ _264_ VGND VGND VPWR VPWR _267_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_27_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_600_ clknet_3_5__leaf_sys_clk net76 net58 VGND VGND VPWR VPWR clk_cnt\[20\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_462_ u_controller.counter_reg\[3\] net64 u_controller.dac_reg\[3\] VGND VGND VPWR
+ VPWR _249_ sky130_fd_sc_hd__a21o_1
X_393_ bit_en net40 _197_ u_spi.data_reg\[0\] VGND VGND VPWR VPWR _199_ sky130_fd_sc_hd__a22oi_1
XFILLER_32_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout34 _153_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_4
XFILLER_13_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout45 u_spi.cmd\[1\] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_4
Xfanout56 net4 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_4
XFILLER_13_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_514_ u_spi.pay\[5\] u_spi.pay\[6\] net29 VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__mux2_1
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_376_ u_spi.pay\[7\] net28 _186_ net109 VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__a22o_1
X_445_ ctrl_reg\[11\] _195_ _197_ u_spi.data_reg\[11\] VGND VGND VPWR VPWR _240_ sky130_fd_sc_hd__a22o_1
XFILLER_6_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_428_ u_spi.miso_buffer\[6\] net31 _205_ VGND VGND VPWR VPWR _227_ sky130_fd_sc_hd__o21a_1
X_359_ _138_ _184_ _172_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__a21boi_1
Xinput2 cs VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_36_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_693_ clknet_3_3__leaf_sys_clk net131 net56 VGND VGND VPWR VPWR bit_int_en sky130_fd_sc_hd__dfrtp_1
XFILLER_15_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_676_ clknet_3_0__leaf_sys_clk net91 net54 VGND VGND VPWR VPWR eoc_flag sky130_fd_sc_hd__dfrtp_1
XFILLER_35_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_530_ _192_ _265_ net29 _152_ VGND VGND VPWR VPWR _266_ sky130_fd_sc_hd__a2bb2o_1
X_461_ u_controller.dac_reg\[2\] net35 _248_ net39 VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__o211a_1
XFILLER_25_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_392_ _134_ u_spi.pay\[1\] VGND VGND VPWR VPWR _198_ sky130_fd_sc_hd__nand2_1
XFILLER_4_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_659_ clknet_3_4__leaf_sys_clk _113_ net57 VGND VGND VPWR VPWR u_spi.pay\[8\] sky130_fd_sc_hd__dfrtp_1
Xfanout35 net36 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_2
XFILLER_13_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout24 _258_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_4
XFILLER_22_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout46 u_spi.cmd\[1\] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_2
Xfanout57 net63 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_4
XFILLER_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_513_ u_spi.pay\[4\] u_spi.pay\[5\] net29 VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__mux2_1
X_444_ u_spi.miso_buffer\[10\] net31 net26 VGND VGND VPWR VPWR _239_ sky130_fd_sc_hd__o21a_1
XFILLER_9_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_375_ net46 _143_ net33 VGND VGND VPWR VPWR _186_ sky130_fd_sc_hd__a21o_1
X_611__65 VGND VGND VPWR VPWR _611__65/HI net65 sky130_fd_sc_hd__conb_1
XFILLER_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_358_ _172_ _183_ _184_ VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__and3_1
X_427_ net101 net32 _224_ _226_ VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__o22a_1
X_289_ u_spi.pay\[5\] VGND VGND VPWR VPWR _141_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 mosi VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_3__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_3__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
X_692_ clknet_3_1__leaf_sys_clk _131_ net54 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_2
XFILLER_7_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_675_ clknet_3_0__leaf_sys_clk _127_ net52 VGND VGND VPWR VPWR u_spi.state\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_460_ u_controller.counter_reg\[2\] net64 u_controller.dac_reg\[2\] VGND VGND VPWR
+ VPWR _248_ sky130_fd_sc_hd__a21o_1
X_391_ u_spi.pay\[0\] _135_ VGND VGND VPWR VPWR _197_ sky130_fd_sc_hd__nor2_4
XFILLER_40_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_658_ clknet_3_4__leaf_sys_clk _112_ net63 VGND VGND VPWR VPWR u_spi.pay\[7\] sky130_fd_sc_hd__dfrtp_1
X_589_ clknet_3_7__leaf_sys_clk net87 net61 VGND VGND VPWR VPWR clk_cnt\[9\] sky130_fd_sc_hd__dfrtp_1
Xfanout58 net60 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_4
Xfanout36 _149_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_2
Xfanout47 net48 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout25 _150_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_4
XFILLER_38_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_512_ u_spi.pay\[3\] u_spi.pay\[4\] net30 VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__mux2_1
X_374_ u_spi.pay\[6\] _156_ _185_ bit_clk_sel VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__a22o_1
X_443_ net105 _193_ _236_ _238_ VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__o22a_1
XFILLER_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_357_ clk_cnt\[6\] _181_ VGND VGND VPWR VPWR _184_ sky130_fd_sc_hd__nand2_1
X_426_ net27 _225_ VGND VGND VPWR VPWR _226_ sky130_fd_sc_hd__and2_1
X_288_ u_spi.pay\[4\] VGND VGND VPWR VPWR _140_ sky130_fd_sc_hd__inv_2
Xinput4 reset_ VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_409_ bit_auto net40 _197_ u_spi.data_reg\[2\] VGND VGND VPWR VPWR _213_ sky130_fd_sc_hd__a22o_1
XFILLER_32_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_691_ clknet_3_1__leaf_sys_clk _130_ net54 VGND VGND VPWR VPWR bit_auto sky130_fd_sc_hd__dfrtp_1
XFILLER_15_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_674_ clknet_3_0__leaf_sys_clk _126_ net54 VGND VGND VPWR VPWR u_spi.state\[0\] sky130_fd_sc_hd__dfrtp_2
XFILLER_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_390_ net40 VGND VGND VPWR VPWR _196_ sky130_fd_sc_hd__inv_2
XFILLER_27_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_657_ clknet_3_4__leaf_sys_clk _111_ net63 VGND VGND VPWR VPWR u_spi.pay\[6\] sky130_fd_sc_hd__dfrtp_1
X_588_ clknet_3_5__leaf_sys_clk net88 net60 VGND VGND VPWR VPWR clk_cnt\[8\] sky130_fd_sc_hd__dfrtp_1
Xfanout26 _205_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_2
Xfanout37 net38 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_2
Xfanout48 net51 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_2
Xfanout59 net60 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_2
X_511_ u_spi.pay\[3\] u_spi.pay\[2\] _260_ VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__mux2_1
XFILLER_9_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_373_ net46 _142_ _155_ VGND VGND VPWR VPWR _185_ sky130_fd_sc_hd__a21o_1
X_442_ _204_ _237_ VGND VGND VPWR VPWR _238_ sky130_fd_sc_hd__and2_1
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_356_ clk_cnt\[6\] _181_ VGND VGND VPWR VPWR _183_ sky130_fd_sc_hd__or2_1
X_287_ u_spi.eoc_sent_high VGND VGND VPWR VPWR _139_ sky130_fd_sc_hd__inv_2
X_425_ bit_clk_sel net40 _197_ u_spi.data_reg\[6\] VGND VGND VPWR VPWR _225_ sky130_fd_sc_hd__a22o_1
Xinput5 sck VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_408_ u_spi.miso_buffer\[1\] net31 net26 VGND VGND VPWR VPWR _212_ sky130_fd_sc_hd__o21a_1
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_339_ _169_ _171_ VGND VGND VPWR VPWR _172_ sky130_fd_sc_hd__nor2_2
XFILLER_32_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_690_ clknet_3_3__leaf_sys_clk _129_ net56 VGND VGND VPWR VPWR bit_en sky130_fd_sc_hd__dfrtp_1
XFILLER_15_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_673_ clknet_3_0__leaf_sys_clk net92 net54 VGND VGND VPWR VPWR u_spi.sck_s2 sky130_fd_sc_hd__dfrtp_1
XFILLER_28_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_14_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_656_ clknet_3_1__leaf_sys_clk _110_ net53 VGND VGND VPWR VPWR u_spi.pay\[5\] sky130_fd_sc_hd__dfrtp_1
X_587_ clknet_3_7__leaf_sys_clk _030_ net61 VGND VGND VPWR VPWR clk_cnt\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout27 _204_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_2
XFILLER_13_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout38 _149_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_2
Xfanout49 net51 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_2
XFILLER_38_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_510_ u_spi.pay\[1\] u_spi.pay\[2\] net29 VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__mux2_1
X_441_ ctrl_reg\[10\] net40 _197_ u_spi.data_reg\[10\] VGND VGND VPWR VPWR _237_ sky130_fd_sc_hd__a22o_1
X_372_ eoc_flag bit_int_en VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__and2_1
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_639_ net47 _094_ net41 VGND VGND VPWR VPWR adc_data_out\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_17_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_424_ u_spi.miso_buffer\[5\] net31 net26 VGND VGND VPWR VPWR _224_ sky130_fd_sc_hd__o21a_1
X_355_ _181_ _182_ _172_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__and3b_1
X_286_ clk_cnt\[7\] VGND VGND VPWR VPWR _138_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_1_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_2_Left_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_407_ net96 net32 _209_ _211_ VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_338_ _160_ _163_ _168_ _170_ VGND VGND VPWR VPWR _171_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_218 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_672_ clknet_3_0__leaf_sys_clk _125_ net52 VGND VGND VPWR VPWR u_spi.bit_cnt\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_2__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_2__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_31_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_586_ clknet_3_7__leaf_sys_clk _029_ net61 VGND VGND VPWR VPWR clk_cnt\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_655_ clknet_3_1__leaf_sys_clk _109_ net53 VGND VGND VPWR VPWR u_spi.pay\[4\] sky130_fd_sc_hd__dfrtp_1
Xfanout39 _148_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_2
Xfanout28 _156_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_2
XFILLER_1_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_440_ u_spi.miso_buffer\[9\] _194_ _205_ VGND VGND VPWR VPWR _236_ sky130_fd_sc_hd__o21a_1
X_371_ u_controller.counter_reg\[11\] net37 u_controller.dac_reg\[11\] VGND VGND VPWR
+ VPWR net9 sky130_fd_sc_hd__a21o_1
XFILLER_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_638_ net47 _093_ net41 VGND VGND VPWR VPWR adc_data_out\[0\] sky130_fd_sc_hd__dfrtp_1
X_569_ clknet_3_6__leaf_sys_clk _059_ net62 VGND VGND VPWR VPWR u_spi.miso_buffer\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_354_ clk_cnt\[5\] _180_ VGND VGND VPWR VPWR _182_ sky130_fd_sc_hd__or2_1
X_423_ net102 net32 _221_ _223_ VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__o22a_1
XFILLER_5_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_285_ u_spi.pay\[2\] VGND VGND VPWR VPWR _137_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_1_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_406_ u_controller.state\[0\] u_controller.state\[1\] _207_ _210_ net27 VGND VGND
+ VPWR VPWR _211_ sky130_fd_sc_hd__o311a_1
XFILLER_25_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_337_ clk_cnt\[9\] clk_cnt\[8\] clk_cnt\[11\] clk_cnt\[10\] VGND VGND VPWR VPWR _170_
+ sky130_fd_sc_hd__or4_1
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_671_ clknet_3_0__leaf_sys_clk _124_ net52 VGND VGND VPWR VPWR u_spi.bit_cnt\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_22_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_654_ clknet_3_1__leaf_sys_clk _108_ net53 VGND VGND VPWR VPWR u_spi.pay\[3\] sky130_fd_sc_hd__dfrtp_1
X_585_ clknet_3_7__leaf_sys_clk _028_ net61 VGND VGND VPWR VPWR clk_cnt\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout29 _261_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_32_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_370_ u_controller.counter_reg\[10\] net37 u_controller.dac_reg\[10\] VGND VGND VPWR
+ VPWR net8 sky130_fd_sc_hd__a21o_1
X_637_ net50 _092_ net44 VGND VGND VPWR VPWR u_controller.counter_reg\[11\] sky130_fd_sc_hd__dfrtp_1
X_568_ clknet_3_3__leaf_sys_clk _058_ net56 VGND VGND VPWR VPWR u_spi.miso_buffer\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_499_ adc_data_out\[6\] _252_ net24 VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__mux2_1
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_40 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_599__77 VGND VGND VPWR VPWR _599__77/HI net77 sky130_fd_sc_hd__conb_1
XFILLER_39_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_353_ clk_cnt\[4\] clk_cnt\[5\] _177_ VGND VGND VPWR VPWR _181_ sky130_fd_sc_hd__and3_1
X_284_ u_spi.pay\[3\] VGND VGND VPWR VPWR _136_ sky130_fd_sc_hd__inv_2
X_422_ net27 _222_ VGND VGND VPWR VPWR _223_ sky130_fd_sc_hd__and2_1
XFILLER_14_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_336_ clk_cnt\[13\] clk_cnt\[12\] clk_cnt\[15\] clk_cnt\[14\] VGND VGND VPWR VPWR
+ _169_ sky130_fd_sc_hd__or4_1
X_405_ bit_start _196_ _198_ u_spi.data_reg\[1\] VGND VGND VPWR VPWR _210_ sky130_fd_sc_hd__o22a_1
XFILLER_25_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_319_ u_spi.state\[0\] u_spi.addr\[0\] u_spi.addr\[1\] u_spi.state\[1\] VGND VGND
+ VPWR VPWR _154_ sky130_fd_sc_hd__or4b_1
XTAP_TAPCELL_ROW_39_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_670_ clknet_3_0__leaf_sys_clk _123_ net52 VGND VGND VPWR VPWR u_spi.bit_cnt\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_28_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_653_ clknet_3_1__leaf_sys_clk _107_ net53 VGND VGND VPWR VPWR u_spi.pay\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_584_ clknet_3_7__leaf_sys_clk _027_ net63 VGND VGND VPWR VPWR clk_cnt\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_567_ clknet_3_3__leaf_sys_clk _057_ net56 VGND VGND VPWR VPWR u_spi.miso_buffer\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_28_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_636_ net49 _091_ net43 VGND VGND VPWR VPWR u_controller.counter_reg\[10\] sky130_fd_sc_hd__dfrtp_1
X_498_ adc_data_out\[5\] _251_ _258_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__mux2_1
XFILLER_5_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_421_ ctrl_reg\[5\] net40 _197_ u_spi.data_reg\[5\] VGND VGND VPWR VPWR _222_ sky130_fd_sc_hd__a22o_1
X_352_ _180_ _172_ _179_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__and3b_1
XFILLER_14_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_283_ u_spi.pay\[1\] VGND VGND VPWR VPWR _135_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_1_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_619_ net48 _074_ net42 VGND VGND VPWR VPWR u_controller.dac_reg\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_595__81 VGND VGND VPWR VPWR _595__81/HI net81 sky130_fd_sc_hd__conb_1
XFILLER_35_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_404_ u_spi.miso_buffer\[0\] net31 net26 VGND VGND VPWR VPWR _209_ sky130_fd_sc_hd__o21a_1
X_335_ _164_ _165_ _166_ _167_ VGND VGND VPWR VPWR _168_ sky130_fd_sc_hd__or4_1
X_592__84 VGND VGND VPWR VPWR _592__84/HI net84 sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_6_Left_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_318_ adc_data_out\[11\] net132 _153_ VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__mux2_1
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_652_ clknet_3_1__leaf_sys_clk _106_ net53 VGND VGND VPWR VPWR u_spi.pay\[1\] sky130_fd_sc_hd__dfrtp_2
X_583_ clknet_3_7__leaf_sys_clk _026_ net61 VGND VGND VPWR VPWR clk_cnt\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold1 u_spi.eoc_s1 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_1__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_1__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
X_566_ clknet_3_3__leaf_sys_clk _056_ net56 VGND VGND VPWR VPWR u_spi.miso_buffer\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_28_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_635_ net49 _090_ net43 VGND VGND VPWR VPWR u_controller.counter_reg\[9\] sky130_fd_sc_hd__dfrtp_1
X_497_ adc_data_out\[4\] _250_ net24 VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__mux2_1
XFILLER_5_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_351_ clk_cnt\[4\] _177_ VGND VGND VPWR VPWR _180_ sky130_fd_sc_hd__and2_1
X_420_ u_spi.miso_buffer\[4\] net31 net26 VGND VGND VPWR VPWR _221_ sky130_fd_sc_hd__o21a_1
X_282_ u_spi.pay\[0\] VGND VGND VPWR VPWR _134_ sky130_fd_sc_hd__inv_2
XFILLER_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_549_ u_spi.pay\[2\] net28 _277_ net136 VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__a22o_1
X_618_ net48 _073_ net42 VGND VGND VPWR VPWR u_controller.dac_reg\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_17 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_403_ net134 _208_ _206_ VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__a21o_1
X_334_ clk_cnt\[29\] clk_cnt\[28\] clk_cnt\[31\] clk_cnt\[30\] VGND VGND VPWR VPWR
+ _167_ sky130_fd_sc_hd__or4_1
XFILLER_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_38_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_317_ adc_data_out\[10\] net113 _153_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__mux2_1
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_720_ u_spi.miso_buffer\[11\] _281_ VGND VGND VPWR VPWR miso sky130_fd_sc_hd__ebufn_8
X_651_ clknet_3_0__leaf_sys_clk _105_ net52 VGND VGND VPWR VPWR u_spi.pay\[0\] sky130_fd_sc_hd__dfrtp_4
X_582_ clknet_3_7__leaf_sys_clk _023_ net61 VGND VGND VPWR VPWR clk_cnt\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold2 start_clear_req VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_22_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_634_ net49 _089_ net43 VGND VGND VPWR VPWR u_controller.counter_reg\[8\] sky130_fd_sc_hd__dfrtp_1
X_565_ clknet_3_2__leaf_sys_clk _055_ net55 VGND VGND VPWR VPWR u_spi.miso_buffer\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_496_ adc_data_out\[3\] _249_ net24 VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__mux2_1
XFILLER_8_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_350_ clk_cnt\[4\] _177_ VGND VGND VPWR VPWR _179_ sky130_fd_sc_hd__or2_1
XFILLER_5_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_617_ net47 _072_ net42 VGND VGND VPWR VPWR u_controller.dac_reg\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_29_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_548_ _137_ net45 net33 VGND VGND VPWR VPWR _277_ sky130_fd_sc_hd__a21o_1
X_479_ u_controller.dac_reg\[11\] net38 _257_ _148_ VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__o211a_1
XFILLER_35_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_402_ net26 _207_ VGND VGND VPWR VPWR _208_ sky130_fd_sc_hd__nor2_1
XFILLER_25_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_172 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_333_ clk_cnt\[25\] clk_cnt\[24\] clk_cnt\[27\] clk_cnt\[26\] VGND VGND VPWR VPWR
+ _166_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_19_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_316_ adc_data_out\[9\] net125 net34 VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__mux2_1
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_608__68 VGND VGND VPWR VPWR _608__68/HI net68 sky130_fd_sc_hd__conb_1
X_650_ clknet_3_3__leaf_sys_clk _034_ net53 VGND VGND VPWR VPWR bit_start sky130_fd_sc_hd__dfrtp_1
XFILLER_31_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_581_ clknet_3_7__leaf_sys_clk _012_ net61 VGND VGND VPWR VPWR clk_cnt\[1\] sky130_fd_sc_hd__dfrtp_2
XTAP_TAPCELL_ROW_41_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold3 _128_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlygate4sd3_1
X_633_ net49 _088_ net44 VGND VGND VPWR VPWR u_controller.counter_reg\[7\] sky130_fd_sc_hd__dfrtp_1
X_564_ clknet_3_2__leaf_sys_clk _054_ net55 VGND VGND VPWR VPWR u_spi.miso_buffer\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_495_ adc_data_out\[2\] _248_ net24 VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__mux2_1
XFILLER_39_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_616_ net47 _071_ net41 VGND VGND VPWR VPWR u_controller.dac_reg\[2\] sky130_fd_sc_hd__dfrtp_1
X_547_ u_spi.pay\[0\] net28 _276_ net93 VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__a22o_1
X_478_ u_controller.counter_reg\[11\] net1 u_controller.dac_reg\[11\] VGND VGND VPWR
+ VPWR _257_ sky130_fd_sc_hd__a21o_1
X_401_ u_spi.pay\[0\] _135_ VGND VGND VPWR VPWR _207_ sky130_fd_sc_hd__nand2_1
XFILLER_26_184 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_332_ clk_cnt\[17\] clk_cnt\[16\] clk_cnt\[19\] clk_cnt\[18\] VGND VGND VPWR VPWR
+ _165_ sky130_fd_sc_hd__or4_1
XFILLER_41_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_176 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_315_ adc_data_out\[8\] net114 net34 VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__mux2_1
XFILLER_11_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_21_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_580_ clknet_3_7__leaf_sys_clk _001_ net61 VGND VGND VPWR VPWR clk_cnt\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_17_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold4 u_spi.sck_s1 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_604__72 VGND VGND VPWR VPWR _604__72/HI net72 sky130_fd_sc_hd__conb_1
XFILLER_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_563_ clknet_3_2__leaf_sys_clk _053_ net55 VGND VGND VPWR VPWR u_spi.miso_buffer\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_632_ net48 _087_ net44 VGND VGND VPWR VPWR u_controller.counter_reg\[6\] sky130_fd_sc_hd__dfrtp_1
X_494_ adc_data_out\[1\] _247_ net24 VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_601__75 VGND VGND VPWR VPWR _601__75/HI net75 sky130_fd_sc_hd__conb_1
XFILLER_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_615_ net47 _070_ net41 VGND VGND VPWR VPWR u_controller.dac_reg\[1\] sky130_fd_sc_hd__dfrtp_1
X_546_ _134_ net45 net33 VGND VGND VPWR VPWR _276_ sky130_fd_sc_hd__a21o_1
X_477_ u_controller.dac_reg\[10\] net37 _256_ _148_ VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__o211a_1
Xclkbuf_3_0__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_0__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_400_ _199_ net26 u_spi.miso_buffer\[0\] net31 VGND VGND VPWR VPWR _206_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_331_ clk_cnt\[21\] clk_cnt\[20\] clk_cnt\[23\] clk_cnt\[22\] VGND VGND VPWR VPWR
+ _164_ sky130_fd_sc_hd__or4_1
XFILLER_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_529_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] u_spi.bit_cnt\[2\] VGND VGND VPWR VPWR
+ _265_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_19_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_314_ adc_data_out\[7\] net115 net34 VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_26_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold5 bit_en VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_29_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_493_ adc_data_out\[0\] _246_ net24 VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__mux2_1
X_631_ net48 _086_ net42 VGND VGND VPWR VPWR u_controller.counter_reg\[5\] sky130_fd_sc_hd__dfrtp_1
X_562_ clknet_3_4__leaf_sys_clk net120 net57 VGND VGND VPWR VPWR ctrl_reg\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_545_ _151_ _275_ net90 VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__a21oi_1
X_614_ net47 _069_ net41 VGND VGND VPWR VPWR u_controller.dac_reg\[0\] sky130_fd_sc_hd__dfrtp_1
X_476_ u_controller.counter_reg\[10\] net1 u_controller.dac_reg\[10\] VGND VGND VPWR
+ VPWR _256_ sky130_fd_sc_hd__a21o_1
X_330_ clk_cnt\[6\] clk_cnt\[7\] _162_ _161_ bit_clk_sel VGND VGND VPWR VPWR _163_
+ sky130_fd_sc_hd__a32o_1
XFILLER_41_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_459_ u_controller.dac_reg\[1\] net35 _247_ net39 VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__o211a_1
X_528_ _200_ _260_ _264_ _262_ net137 VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_1_Left_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_313_ adc_data_out\[6\] net110 net34 VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__mux2_1
XFILLER_36_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_174 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold6 _000_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_15_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_630_ net48 _085_ net42 VGND VGND VPWR VPWR u_controller.counter_reg\[4\] sky130_fd_sc_hd__dfrtp_1
X_492_ _245_ u_controller.state\[0\] u_controller.state\[1\] VGND VGND VPWR VPWR _258_
+ sky130_fd_sc_hd__nor3b_2
X_561_ clknet_3_4__leaf_sys_clk _051_ net57 VGND VGND VPWR VPWR ctrl_reg\[10\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_30_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_610__66 VGND VGND VPWR VPWR _610__66/HI net66 sky130_fd_sc_hd__conb_1
X_613_ clknet_3_7__leaf_sys_clk _068_ net63 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__dfrtp_1
XFILLER_29_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_544_ _273_ _274_ eoc_flag VGND VGND VPWR VPWR _275_ sky130_fd_sc_hd__o21ai_1
X_475_ u_controller.dac_reg\[9\] net37 _255_ net39 VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__o211a_1
XFILLER_26_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_527_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] VGND VGND VPWR VPWR _264_ sky130_fd_sc_hd__nand2_1
XFILLER_17_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_458_ u_controller.counter_reg\[1\] net64 u_controller.dac_reg\[1\] VGND VGND VPWR
+ VPWR _247_ sky130_fd_sc_hd__a21o_1
X_389_ u_spi.pay\[0\] u_spi.pay\[1\] VGND VGND VPWR VPWR _195_ sky130_fd_sc_hd__nor2_1
XFILLER_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_312_ adc_data_out\[5\] net117 net34 VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_21_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_189 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 u_spi.miso_buffer\[2\] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_40_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_560_ clknet_3_4__leaf_sys_clk net122 net57 VGND VGND VPWR VPWR ctrl_reg\[9\] sky130_fd_sc_hd__dfrtp_1
X_491_ u_controller.counter_reg\[11\] net19 net37 VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_689_ clknet_3_7__leaf_sys_clk _037_ net61 VGND VGND VPWR VPWR u_spi.data_reg\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_612_ clknet_3_0__leaf_sys_clk net127 net52 VGND VGND VPWR VPWR u_spi.eoc_sent_high
+ sky130_fd_sc_hd__dfrtp_1
X_543_ u_spi.addr\[0\] u_spi.addr\[1\] _272_ VGND VGND VPWR VPWR _274_ sky130_fd_sc_hd__o21ai_1
X_474_ u_controller.counter_reg\[9\] net64 u_controller.dac_reg\[9\] VGND VGND VPWR
+ VPWR _255_ sky130_fd_sc_hd__a21o_1
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_526_ u_spi.bit_cnt\[0\] _260_ _262_ _263_ VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__o22a_1
XFILLER_17_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_388_ net2 _192_ u_spi.sck_s1 u_spi.sck_s2 VGND VGND VPWR VPWR _194_ sky130_fd_sc_hd__or4b_2
X_457_ u_controller.dac_reg\[0\] net35 _246_ net39 VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__o211a_1
X_311_ adc_data_out\[4\] net116 net34 VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_509_ u_spi.pay\[0\] u_spi.pay\[1\] net29 VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold8 u_spi.miso_buffer\[1\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_32_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_490_ u_controller.counter_reg\[11\] net38 net25 u_controller.counter_reg\[10\] VGND
+ VGND VPWR VPWR _091_ sky130_fd_sc_hd__a22o_1
XFILLER_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_688_ clknet_3_7__leaf_sys_clk _036_ net61 VGND VGND VPWR VPWR u_spi.data_reg\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_542_ u_spi.state\[0\] u_spi.cmd\[0\] net45 u_spi.state\[1\] VGND VGND VPWR VPWR
+ _273_ sky130_fd_sc_hd__or4b_1
X_473_ u_controller.dac_reg\[8\] net37 _254_ _148_ VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__o211a_1
X_611_ clknet_3_5__leaf_sys_clk net65 net58 VGND VGND VPWR VPWR clk_cnt\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_35 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_456_ u_controller.counter_reg\[0\] net64 u_controller.dac_reg\[0\] VGND VGND VPWR
+ VPWR _246_ sky130_fd_sc_hd__a21o_1
X_525_ u_spi.bit_cnt\[0\] u_spi.state\[0\] VGND VGND VPWR VPWR _263_ sky130_fd_sc_hd__and2b_1
X_387_ u_spi.sck_s1 u_spi.sck_s2 _191_ u_spi.state\[0\] VGND VGND VPWR VPWR _193_
+ sky130_fd_sc_hd__and4b_1
XFILLER_15_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_310_ adc_data_out\[3\] net123 net34 VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_508_ u_spi.pay\[0\] net3 _260_ VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__mux2_1
X_439_ net99 net32 _233_ _235_ VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_5_Left_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold9 u_spi.miso_buffer\[3\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_40_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Left_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_687_ clknet_3_7__leaf_sys_clk _046_ net63 VGND VGND VPWR VPWR u_spi.data_reg\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_7_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_610_ clknet_3_5__leaf_sys_clk net66 net58 VGND VGND VPWR VPWR clk_cnt\[30\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_34_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_589__87 VGND VGND VPWR VPWR _589__87/HI net87 sky130_fd_sc_hd__conb_1
X_541_ u_spi.addr\[1\] _139_ u_spi.addr\[0\] VGND VGND VPWR VPWR _272_ sky130_fd_sc_hd__o21ai_1
X_472_ u_controller.counter_reg\[8\] net64 u_controller.dac_reg\[8\] VGND VGND VPWR
+ VPWR _254_ sky130_fd_sc_hd__a21o_1
XFILLER_20_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_455_ net50 _172_ VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__xnor2_1
X_524_ _152_ net29 VGND VGND VPWR VPWR _262_ sky130_fd_sc_hd__and2_1
X_386_ u_spi.state\[1\] u_spi.state\[0\] VGND VGND VPWR VPWR _192_ sky130_fd_sc_hd__nand2b_1
XFILLER_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_507_ _259_ u_spi.sck_s2 _191_ VGND VGND VPWR VPWR _261_ sky130_fd_sc_hd__or3b_1
XPHY_EDGE_ROW_21_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_369_ u_controller.counter_reg\[9\] net37 u_controller.dac_reg\[9\] VGND VGND VPWR
+ VPWR net18 sky130_fd_sc_hd__a21o_1
X_438_ net27 _234_ VGND VGND VPWR VPWR _235_ sky130_fd_sc_hd__and2_1
XFILLER_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_3_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_686_ clknet_3_6__leaf_sys_clk _045_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[8\]
+ sky130_fd_sc_hd__dfrtp_1
Xclkbuf_0_sys_clk sys_clk VGND VGND VPWR VPWR clknet_0_sys_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_540_ _191_ _270_ VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__and2_1
XFILLER_29_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_471_ u_controller.dac_reg\[7\] net38 _253_ _148_ VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__o211a_1
XFILLER_29_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_669_ clknet_3_0__leaf_sys_clk _122_ net52 VGND VGND VPWR VPWR u_spi.bit_cnt\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_35_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_523_ u_spi.cmd\[0\] net45 net29 VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__mux2_1
XFILLER_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_454_ net126 eoc_flag _208_ VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__mux2_1
X_385_ net2 u_spi.state\[1\] VGND VGND VPWR VPWR _191_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_18_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_506_ u_spi.sck_s2 _191_ u_spi.state\[0\] u_spi.sck_s1 VGND VGND VPWR VPWR _260_
+ sky130_fd_sc_hd__and4b_2
X_299_ u_controller.state\[0\] u_controller.state\[1\] VGND VGND VPWR VPWR _149_ sky130_fd_sc_hd__and2b_1
X_368_ u_controller.counter_reg\[8\] net38 u_controller.dac_reg\[8\] VGND VGND VPWR
+ VPWR net17 sky130_fd_sc_hd__a21o_1
X_437_ ctrl_reg\[9\] net40 _197_ u_spi.data_reg\[9\] VGND VGND VPWR VPWR _234_ sky130_fd_sc_hd__a22o_1
XFILLER_28_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_685_ clknet_3_6__leaf_sys_clk _044_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_598__78 VGND VGND VPWR VPWR _598__78/HI net78 sky130_fd_sc_hd__conb_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_470_ u_controller.counter_reg\[7\] net64 u_controller.dac_reg\[7\] VGND VGND VPWR
+ VPWR _253_ sky130_fd_sc_hd__a21o_1
XFILLER_4_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_668_ clknet_3_0__leaf_sys_clk _121_ net52 VGND VGND VPWR VPWR u_spi.bit_cnt\[0\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_35_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_599_ clknet_3_5__leaf_sys_clk net77 net59 VGND VGND VPWR VPWR clk_cnt\[19\] sky130_fd_sc_hd__dfrtp_1
XFILLER_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_453_ adc_en_n net39 net25 VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__a21oi_1
X_522_ u_spi.cmd\[0\] u_spi.addr\[1\] _260_ VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__mux2_1
XFILLER_17_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_384_ u_spi.pay\[11\] net28 _190_ net119 VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__a22o_1
XFILLER_25_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_505_ u_spi.state\[0\] u_spi.sck_s1 VGND VGND VPWR VPWR _259_ sky130_fd_sc_hd__nand2_1
X_436_ u_spi.miso_buffer\[8\] _194_ net26 VGND VGND VPWR VPWR _233_ sky130_fd_sc_hd__o21a_1
XFILLER_42_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_298_ net39 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__inv_2
X_367_ u_controller.counter_reg\[7\] net38 u_controller.dac_reg\[7\] VGND VGND VPWR
+ VPWR net16 sky130_fd_sc_hd__a21o_1
XFILLER_3_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_419_ net98 net32 _218_ _220_ VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__o22a_1
XFILLER_33_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_684_ clknet_3_6__leaf_sys_clk _043_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_7_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_667_ clknet_3_0__leaf_sys_clk net5 net52 VGND VGND VPWR VPWR u_spi.sck_s1 sky130_fd_sc_hd__dfrtp_1
X_598_ clknet_3_5__leaf_sys_clk net78 net58 VGND VGND VPWR VPWR clk_cnt\[18\] sky130_fd_sc_hd__dfrtp_1
X_594__82 VGND VGND VPWR VPWR _594__82/HI net82 sky130_fd_sc_hd__conb_1
XFILLER_34_171 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_452_ net35 _245_ adc_en_n net19 VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__a211oi_1
X_521_ u_spi.addr\[0\] u_spi.addr\[1\] net29 VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__mux2_1
X_383_ net46 _147_ _155_ VGND VGND VPWR VPWR _190_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_27_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_719_ net19 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
XFILLER_16_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_591__85 VGND VGND VPWR VPWR _591__85/HI net85 sky130_fd_sc_hd__conb_1
XFILLER_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_366_ u_controller.counter_reg\[6\] net36 u_controller.dac_reg\[6\] VGND VGND VPWR
+ VPWR net15 sky130_fd_sc_hd__a21o_1
XFILLER_26_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_435_ net107 net32 _230_ _232_ VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__o22a_1
X_504_ adc_data_out\[11\] _257_ net24 VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__mux2_1
XFILLER_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_297_ u_controller.state\[1\] u_controller.state\[0\] VGND VGND VPWR VPWR _148_ sky130_fd_sc_hd__nand2b_2
XTAP_TAPCELL_ROW_6_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_418_ net27 _219_ VGND VGND VPWR VPWR _220_ sky130_fd_sc_hd__and2_1
X_349_ _177_ _178_ _172_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__and3b_1
XFILLER_5_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_217 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_683_ clknet_3_3__leaf_sys_clk _042_ net56 VGND VGND VPWR VPWR u_spi.data_reg\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_666_ clknet_3_1__leaf_sys_clk _120_ net53 VGND VGND VPWR VPWR u_spi.cmd\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_597_ clknet_3_5__leaf_sys_clk net79 net58 VGND VGND VPWR VPWR clk_cnt\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_520_ u_spi.addr\[0\] u_spi.pay\[11\] _260_ VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__mux2_1
X_451_ u_controller.counter_reg\[1\] u_controller.counter_reg\[3\] _242_ _244_ VGND
+ VGND VPWR VPWR _245_ sky130_fd_sc_hd__or4_1
X_382_ u_spi.pay\[10\] _156_ _189_ net112 VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__a22o_1
XFILLER_40_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_649_ net50 _104_ net43 VGND VGND VPWR VPWR adc_data_out\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_503_ adc_data_out\[10\] _256_ _258_ VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__mux2_1
X_296_ u_controller.state\[0\] u_controller.state\[1\] VGND VGND VPWR VPWR adc_ack
+ sky130_fd_sc_hd__and2_1
XFILLER_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_365_ u_controller.counter_reg\[5\] net36 u_controller.dac_reg\[5\] VGND VGND VPWR
+ VPWR net14 sky130_fd_sc_hd__a21o_1
X_434_ net27 _231_ VGND VGND VPWR VPWR _232_ sky130_fd_sc_hd__and2_1
XFILLER_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_52 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Left_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_417_ bit_int_en net40 _197_ u_spi.data_reg\[4\] VGND VGND VPWR VPWR _219_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_348_ clk_cnt\[1\] clk_cnt\[0\] clk_cnt\[2\] clk_cnt\[3\] VGND VGND VPWR VPWR _178_
+ sky130_fd_sc_hd__a31o_1
XFILLER_5_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_682_ clknet_3_3__leaf_sys_clk _041_ net56 VGND VGND VPWR VPWR u_spi.data_reg\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_7_211 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_665_ clknet_3_1__leaf_sys_clk _119_ net53 VGND VGND VPWR VPWR u_spi.cmd\[0\] sky130_fd_sc_hd__dfrtp_2
Xhold50 u_spi.miso_buffer\[11\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
X_596_ clknet_3_5__leaf_sys_clk net80 net58 VGND VGND VPWR VPWR clk_cnt\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_450_ u_controller.counter_reg\[2\] _243_ u_controller.counter_reg\[0\] VGND VGND
+ VPWR VPWR _244_ sky130_fd_sc_hd__or3b_1
X_381_ net46 _146_ net33 VGND VGND VPWR VPWR _189_ sky130_fd_sc_hd__a21o_1
XFILLER_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_648_ net50 _103_ net43 VGND VGND VPWR VPWR adc_data_out\[10\] sky130_fd_sc_hd__dfrtp_1
X_579_ clknet_3_2__leaf_sys_clk _033_ net52 VGND VGND VPWR VPWR start_clear_req sky130_fd_sc_hd__dfrtp_1
XFILLER_36_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_433_ ctrl_reg\[8\] net40 _197_ u_spi.data_reg\[8\] VGND VGND VPWR VPWR _231_ sky130_fd_sc_hd__a22o_1
X_502_ adc_data_out\[9\] _255_ net24 VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__mux2_1
X_364_ u_controller.counter_reg\[4\] net36 u_controller.dac_reg\[4\] VGND VGND VPWR
+ VPWR net13 sky130_fd_sc_hd__a21o_1
X_295_ u_spi.pay\[11\] VGND VGND VPWR VPWR _147_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_23_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_416_ u_spi.miso_buffer\[3\] net31 net26 VGND VGND VPWR VPWR _218_ sky130_fd_sc_hd__o21a_1
X_347_ clk_cnt\[1\] clk_cnt\[0\] clk_cnt\[3\] clk_cnt\[2\] VGND VGND VPWR VPWR _177_
+ sky130_fd_sc_hd__and4_1
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_607__69 VGND VGND VPWR VPWR _607__69/HI net69 sky130_fd_sc_hd__conb_1
XFILLER_15_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_681_ clknet_3_3__leaf_sys_clk _040_ net56 VGND VGND VPWR VPWR u_spi.data_reg\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_18_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold40 ctrl_reg\[8\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
X_664_ clknet_3_1__leaf_sys_clk _118_ net53 VGND VGND VPWR VPWR u_spi.addr\[1\] sky130_fd_sc_hd__dfrtp_1
X_595_ clknet_3_5__leaf_sys_clk net81 net60 VGND VGND VPWR VPWR clk_cnt\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_380_ u_spi.pay\[9\] net28 _188_ net121 VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__a22o_1
Xoutput6 net50 VGND VGND VPWR VPWR adc_clk_out sky130_fd_sc_hd__buf_2
X_578_ clknet_3_2__leaf_sys_clk net94 net55 VGND VGND VPWR VPWR adc_en_n sky130_fd_sc_hd__dfstp_1
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_647_ net49 _102_ net43 VGND VGND VPWR VPWR adc_data_out\[9\] sky130_fd_sc_hd__dfrtp_1
.ends
