* NGSPICE file created from spi_adc.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinvlp_4 abstract view
.subckt sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_2 abstract view
.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__bufinv_16 abstract view
.subckt sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_1 abstract view
.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__ebufn_8 abstract view
.subckt sky130_fd_sc_hd__ebufn_8 A TE_B VGND VNB VPB VPWR Z
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

.subckt spi_adc VGND VPWR adc_clk_out comparator cs dac[0] dac[10] dac[11] dac[1]
+ dac[2] dac[3] dac[4] dac[5] dac[6] dac[7] dac[8] dac[9] dac_rst irq miso mosi pwr_gate
+ reset_ sample_and_hold sck sys_clk vref_sel
XTAP_TAPCELL_ROW_9_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_501_ u_controller.dac_reg\[1\] net35 _269_ net39 VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__o211a_1
XFILLER_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_432_ u_spi.pay\[0\] _136_ VGND VGND VPWR VPWR _218_ sky130_fd_sc_hd__nor2_1
XFILLER_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_363_ u_controller.counter_reg\[4\] net36 u_controller.dac_reg\[4\] VGND VGND VPWR
+ VPWR net13 sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_23_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_294_ u_spi.pay\[9\] VGND VGND VPWR VPWR _146_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_29_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_346_ net123 _178_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__nor2_1
X_415_ u_spi.pay\[5\] net28 _207_ net111 VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__a22o_1
XFILLER_24_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_329_ clk_cnt\[1\] clk_cnt\[0\] clk_cnt\[2\] VGND VGND VPWR VPWR _162_ sky130_fd_sc_hd__o21a_1
XFILLER_12_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_680_ net46 _122_ net42 VGND VGND VPWR VPWR adc_data_out\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold41 u_spi.addr\[0\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 ctrl_reg\[11\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_663_ net45 _105_ net40 VGND VGND VPWR VPWR u_controller.counter_reg\[2\] sky130_fd_sc_hd__dfrtp_1
X_594_ clknet_3_4__leaf_sys_clk _071_ net57 VGND VGND VPWR VPWR ctrl_reg\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput7 net7 VGND VGND VPWR VPWR dac[0] sky130_fd_sc_hd__buf_2
Xoutput20 net20 VGND VGND VPWR VPWR irq sky130_fd_sc_hd__buf_2
X_577_ clknet_3_2__leaf_sys_clk _039_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_646_ clknet_3_5__leaf_sys_clk net65 net59 VGND VGND VPWR VPWR clk_cnt\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_500_ u_controller.counter_reg\[1\] net64 u_controller.dac_reg\[1\] VGND VGND VPWR
+ VPWR _269_ sky130_fd_sc_hd__a21o_1
X_362_ u_controller.counter_reg\[3\] net36 u_controller.dac_reg\[3\] VGND VGND VPWR
+ VPWR net12 sky130_fd_sc_hd__a21o_1
X_431_ _134_ _186_ _215_ VGND VGND VPWR VPWR _217_ sky130_fd_sc_hd__or3_1
XFILLER_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_293_ u_spi.pay\[8\] VGND VGND VPWR VPWR _145_ sky130_fd_sc_hd__inv_2
XFILLER_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_629_ clknet_3_7__leaf_sys_clk net82 net59 VGND VGND VPWR VPWR clk_cnt\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_42_229 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_19_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_414_ net50 _142_ _157_ VGND VGND VPWR VPWR _207_ sky130_fd_sc_hd__a21o_1
XFILLER_33_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_345_ _164_ _176_ _177_ VGND VGND VPWR VPWR _178_ sky130_fd_sc_hd__or3b_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_328_ net110 net21 _161_ VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_31_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_662_ net45 _104_ net41 VGND VGND VPWR VPWR u_controller.counter_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xhold42 u_spi.addr\[1\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 bit_en VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 u_spi.data_reg\[9\] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
X_593_ clknet_3_6__leaf_sys_clk _070_ net62 VGND VGND VPWR VPWR ctrl_reg\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Left_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_7__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_7__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_15_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_154 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_88 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput21 net21 VGND VGND VPWR VPWR pwr_gate sky130_fd_sc_hd__buf_2
Xoutput10 net10 VGND VGND VPWR VPWR dac[1] sky130_fd_sc_hd__buf_2
XFILLER_0_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput8 net8 VGND VGND VPWR VPWR dac[10] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_33_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_645_ clknet_3_5__leaf_sys_clk net66 net59 VGND VGND VPWR VPWR clk_cnt\[30\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_576_ clknet_3_2__leaf_sys_clk _038_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_31_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_361_ u_controller.counter_reg\[2\] net36 u_controller.dac_reg\[2\] VGND VGND VPWR
+ VPWR net11 sky130_fd_sc_hd__a21o_1
X_430_ _134_ _186_ _215_ VGND VGND VPWR VPWR _216_ sky130_fd_sc_hd__nor3_1
XFILLER_13_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_292_ u_spi.pay\[7\] VGND VGND VPWR VPWR _144_ sky130_fd_sc_hd__inv_2
XFILLER_42_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_628_ clknet_3_7__leaf_sys_clk net83 net60 VGND VGND VPWR VPWR clk_cnt\[13\] sky130_fd_sc_hd__dfrtp_1
X_559_ clknet_3_4__leaf_sys_clk _051_ net57 VGND VGND VPWR VPWR u_spi.pay\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_413_ u_spi.pay\[4\] net28 _206_ net129 VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__a22o_1
X_344_ u_controller.state\[1\] u_controller.state\[0\] _161_ VGND VGND VPWR VPWR _177_
+ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_20_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_327_ net139 bit_auto bit_en VGND VGND VPWR VPWR _161_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_31_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold32 u_spi.data_reg\[0\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
X_661_ net45 _103_ net41 VGND VGND VPWR VPWR u_controller.counter_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xhold43 bit_auto VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 ctrl_reg\[5\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 ctrl_reg\[7\] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dlygate4sd3_1
X_592_ clknet_3_6__leaf_sys_clk net135 net62 VGND VGND VPWR VPWR bit_clk_sel sky130_fd_sc_hd__dfrtp_1
XFILLER_19_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput11 net11 VGND VGND VPWR VPWR dac[2] sky130_fd_sc_hd__buf_2
XFILLER_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput9 net9 VGND VGND VPWR VPWR dac[11] sky130_fd_sc_hd__buf_2
Xoutput22 net22 VGND VGND VPWR VPWR sample_and_hold sky130_fd_sc_hd__buf_2
X_575_ clknet_3_2__leaf_sys_clk _035_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_644_ clknet_3_5__leaf_sys_clk net67 net59 VGND VGND VPWR VPWR clk_cnt\[29\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_360_ u_controller.counter_reg\[1\] net35 u_controller.dac_reg\[1\] VGND VGND VPWR
+ VPWR net10 sky130_fd_sc_hd__a21o_1
XFILLER_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_291_ u_spi.pay\[6\] VGND VGND VPWR VPWR _143_ sky130_fd_sc_hd__inv_2
XFILLER_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_627_ clknet_3_7__leaf_sys_clk net84 net60 VGND VGND VPWR VPWR clk_cnt\[12\] sky130_fd_sc_hd__dfrtp_1
X_558_ clknet_3_4__leaf_sys_clk _050_ net57 VGND VGND VPWR VPWR u_spi.pay\[10\] sky130_fd_sc_hd__dfrtp_1
X_489_ u_controller.counter_reg\[1\] u_controller.counter_reg\[3\] u_controller.counter_reg\[2\]
+ u_controller.counter_reg\[0\] VGND VGND VPWR VPWR _263_ sky130_fd_sc_hd__or4b_1
XFILLER_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_412_ net50 _141_ net33 VGND VGND VPWR VPWR _206_ sky130_fd_sc_hd__a21o_1
XFILLER_37_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_343_ _168_ _171_ _173_ _175_ VGND VGND VPWR VPWR _176_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_34_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_326_ net125 _159_ _160_ net28 u_spi.pay\[1\] VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_0_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_309_ adc_data_out\[0\] net122 net34 VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__mux2_1
XFILLER_4_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold22 u_spi.bit_cnt\[4\] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 u_spi.miso_buffer\[6\] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold33 clk_cnt\[0\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
X_591_ clknet_3_6__leaf_sys_clk _068_ net62 VGND VGND VPWR VPWR ctrl_reg\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold44 bit_clk_sel VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
X_660_ net47 _102_ net43 VGND VGND VPWR VPWR u_controller.dac_reg\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput23 net23 VGND VGND VPWR VPWR vref_sel sky130_fd_sc_hd__buf_2
Xoutput12 net12 VGND VGND VPWR VPWR dac[3] sky130_fd_sc_hd__buf_2
X_574_ clknet_3_3__leaf_sys_clk adc_ack net55 VGND VGND VPWR VPWR u_spi.eoc_s1 sky130_fd_sc_hd__dfrtp_1
X_643_ clknet_3_5__leaf_sys_clk net68 net59 VGND VGND VPWR VPWR clk_cnt\[28\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_290_ u_spi.pay\[5\] VGND VGND VPWR VPWR _142_ sky130_fd_sc_hd__inv_2
XFILLER_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_488_ u_controller.counter_reg\[5\] u_controller.counter_reg\[4\] u_controller.counter_reg\[7\]
+ u_controller.counter_reg\[6\] VGND VGND VPWR VPWR _262_ sky130_fd_sc_hd__or4_1
X_557_ clknet_3_4__leaf_sys_clk _049_ net57 VGND VGND VPWR VPWR u_spi.pay\[9\] sky130_fd_sc_hd__dfrtp_1
X_626_ clknet_3_7__leaf_sys_clk net85 net60 VGND VGND VPWR VPWR clk_cnt\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_12_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_5_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_411_ u_spi.pay\[3\] net28 _205_ net23 VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__a22o_1
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_342_ clk_cnt\[3\] clk_cnt\[5\] _174_ VGND VGND VPWR VPWR _175_ sky130_fd_sc_hd__and3_1
XFILLER_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_609_ clknet_3_0__leaf_sys_clk _086_ net52 VGND VGND VPWR VPWR u_spi.miso_buffer\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_325_ _136_ net50 net33 VGND VGND VPWR VPWR _160_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_0_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkload0 clknet_3_0__leaf_sys_clk VGND VGND VPWR VPWR clkload0/Y sky130_fd_sc_hd__clkinv_2
X_308_ _154_ start_clear_req _152_ VGND VGND VPWR VPWR _155_ sky130_fd_sc_hd__mux2_1
XFILLER_41_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold23 u_spi.data_reg\[2\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 u_spi.miso_buffer\[5\] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 u_spi.miso_buffer\[11\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 _069_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
X_590_ clknet_3_6__leaf_sys_clk _067_ net62 VGND VGND VPWR VPWR bit_int_en sky130_fd_sc_hd__dfrtp_1
XFILLER_6_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput13 net13 VGND VGND VPWR VPWR dac[4] sky130_fd_sc_hd__buf_2
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_642_ clknet_3_5__leaf_sys_clk net69 net58 VGND VGND VPWR VPWR clk_cnt\[27\] sky130_fd_sc_hd__dfrtp_1
X_573_ clknet_3_3__leaf_sys_clk _063_ net53 VGND VGND VPWR VPWR eoc_flag sky130_fd_sc_hd__dfrtp_1
XFILLER_16_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_26_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_625_ clknet_3_7__leaf_sys_clk net86 net60 VGND VGND VPWR VPWR clk_cnt\[10\] sky130_fd_sc_hd__dfrtp_1
X_487_ u_controller.counter_reg\[9\] u_controller.counter_reg\[8\] u_controller.counter_reg\[11\]
+ u_controller.counter_reg\[10\] VGND VGND VPWR VPWR _261_ sky130_fd_sc_hd__or4_1
X_556_ clknet_3_4__leaf_sys_clk _048_ net57 VGND VGND VPWR VPWR u_spi.pay\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_6__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_6__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_35_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_410_ _137_ net49 net33 VGND VGND VPWR VPWR _205_ sky130_fd_sc_hd__a21o_1
X_341_ clk_cnt\[1\] clk_cnt\[0\] clk_cnt\[2\] VGND VGND VPWR VPWR _174_ sky130_fd_sc_hd__a21o_1
XFILLER_5_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_608_ clknet_3_0__leaf_sys_clk _085_ net52 VGND VGND VPWR VPWR u_spi.miso_buffer\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_34_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_539_ _272_ adc_data_out\[4\] net24 VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_324_ start_clear_req net33 VGND VGND VPWR VPWR _159_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_24_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkload1 clknet_3_1__leaf_sys_clk VGND VGND VPWR VPWR clkload1/Y sky130_fd_sc_hd__clkinvlp_4
XFILLER_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_307_ u_spi.state\[0\] u_spi.state\[1\] VGND VGND VPWR VPWR _154_ sky130_fd_sc_hd__or2_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold24 u_spi.data_reg\[4\] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 bit_start VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 ctrl_reg\[9\] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold46 u_spi.data_reg\[11\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput14 net14 VGND VGND VPWR VPWR dac[5] sky130_fd_sc_hd__buf_2
X_572_ clknet_3_0__leaf_sys_clk _062_ net51 VGND VGND VPWR VPWR u_spi.state\[1\] sky130_fd_sc_hd__dfrtp_2
X_641_ clknet_3_5__leaf_sys_clk net70 net59 VGND VGND VPWR VPWR clk_cnt\[26\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_26_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_555_ clknet_3_4__leaf_sys_clk _047_ net59 VGND VGND VPWR VPWR u_spi.pay\[7\] sky130_fd_sc_hd__dfrtp_1
X_624_ clknet_3_6__leaf_sys_clk net87 net60 VGND VGND VPWR VPWR clk_cnt\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_36_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_486_ net124 net32 _258_ _260_ VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__o22a_1
X_627__84 VGND VGND VPWR VPWR _627__84/HI net84 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_5_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_340_ _169_ _170_ _172_ VGND VGND VPWR VPWR _173_ sky130_fd_sc_hd__or3_1
X_624__87 VGND VGND VPWR VPWR _624__87/HI net87 sky130_fd_sc_hd__conb_1
X_538_ _271_ adc_data_out\[3\] net24 VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__mux2_1
X_607_ clknet_3_0__leaf_sys_clk _084_ net52 VGND VGND VPWR VPWR u_spi.miso_buffer\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_34_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_469_ net29 _247_ VGND VGND VPWR VPWR _248_ sky130_fd_sc_hd__nor2_1
XFILLER_4_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_61 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout60 net63 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_4
XFILLER_9_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_323_ net49 u_spi.cmd\[0\] net33 VGND VGND VPWR VPWR _158_ sky130_fd_sc_hd__a21oi_2
XFILLER_1_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_41_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkload2 clknet_3_2__leaf_sys_clk VGND VGND VPWR VPWR clkload2/Y sky130_fd_sc_hd__clkinv_4
XFILLER_11_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_306_ u_spi.state\[0\] u_spi.state\[1\] VGND VGND VPWR VPWR _153_ sky130_fd_sc_hd__nor2_1
XFILLER_27_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold25 ctrl_reg\[10\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 u_spi.data_reg\[8\] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 _072_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 u_spi.data_reg\[10\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput15 net15 VGND VGND VPWR VPWR dac[6] sky130_fd_sc_hd__buf_2
X_571_ clknet_3_1__leaf_sys_clk _061_ net51 VGND VGND VPWR VPWR u_spi.state\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_16_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_640_ clknet_3_5__leaf_sys_clk net71 net58 VGND VGND VPWR VPWR clk_cnt\[25\] sky130_fd_sc_hd__dfrtp_1
XFILLER_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_485_ net29 _259_ VGND VGND VPWR VPWR _260_ sky130_fd_sc_hd__nor2_1
X_554_ net2 VGND VGND VPWR VPWR _281_ sky130_fd_sc_hd__buf_1
X_623_ clknet_3_7__leaf_sys_clk net88 net59 VGND VGND VPWR VPWR clk_cnt\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_537_ _270_ adc_data_out\[2\] net24 VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__mux2_1
X_606_ clknet_3_0__leaf_sys_clk _083_ net54 VGND VGND VPWR VPWR u_spi.miso_buffer\[8\]
+ sky130_fd_sc_hd__dfrtp_1
X_468_ u_spi.data_reg\[7\] net30 _219_ ctrl_reg\[7\] VGND VGND VPWR VPWR _247_ sky130_fd_sc_hd__a22oi_1
XFILLER_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_399_ _186_ _199_ VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__nor2_1
XFILLER_4_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_322_ net49 u_spi.cmd\[0\] _156_ u_spi.state\[1\] _134_ VGND VGND VPWR VPWR _157_
+ sky130_fd_sc_hd__o2111ai_4
Xfanout61 net62 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_2
Xfanout50 u_spi.cmd\[1\] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_30_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkload3 clknet_3_3__leaf_sys_clk VGND VGND VPWR VPWR clkload3/Y sky130_fd_sc_hd__clkinvlp_4
X_305_ u_spi.eoc_s2 u_spi.eoc_s1 VGND VGND VPWR VPWR _152_ sky130_fd_sc_hd__and2b_1
XFILLER_37_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold37 u_spi.data_reg\[3\] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 u_spi.miso_buffer\[9\] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 start_clear_req VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 _073_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput16 net16 VGND VGND VPWR VPWR dac[7] sky130_fd_sc_hd__buf_2
X_570_ clknet_3_0__leaf_sys_clk net92 net51 VGND VGND VPWR VPWR u_spi.sck_s2 sky130_fd_sc_hd__dfrtp_1
X_639__72 VGND VGND VPWR VPWR _639__72/HI net72 sky130_fd_sc_hd__conb_1
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_636__75 VGND VGND VPWR VPWR _636__75/HI net75 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_8_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_622_ clknet_3_7__leaf_sys_clk net89 net60 VGND VGND VPWR VPWR clk_cnt\[7\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_484_ u_spi.data_reg\[11\] _218_ _219_ ctrl_reg\[11\] VGND VGND VPWR VPWR _259_ sky130_fd_sc_hd__a22oi_2
X_553_ u_spi.pay\[5\] u_spi.pay\[6\] _190_ VGND VGND VPWR VPWR _133_ sky130_fd_sc_hd__mux2_1
XFILLER_8_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_633__78 VGND VGND VPWR VPWR _633__78/HI net78 sky130_fd_sc_hd__conb_1
XFILLER_37_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_605_ clknet_3_3__leaf_sys_clk _082_ net53 VGND VGND VPWR VPWR u_spi.miso_buffer\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_42_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_398_ _134_ u_spi.bit_cnt\[4\] _187_ _197_ VGND VGND VPWR VPWR _199_ sky130_fd_sc_hd__or4b_1
X_536_ _269_ adc_data_out\[1\] net24 VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__mux2_1
X_467_ u_spi.miso_buffer\[6\] net31 _224_ VGND VGND VPWR VPWR _246_ sky130_fd_sc_hd__o21a_1
XFILLER_27_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_5__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_5__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
Xfanout62 net63 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_4
Xfanout40 net41 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_4
Xfanout51 net54 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_4
XFILLER_14_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_321_ u_spi.addr\[0\] u_spi.addr\[1\] VGND VGND VPWR VPWR _156_ sky130_fd_sc_hd__nor2_1
XFILLER_13_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_519_ u_controller.dac_reg\[10\] net38 _278_ net39 VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__o211a_1
Xclkload4 clknet_3_4__leaf_sys_clk VGND VGND VPWR VPWR clkload4/Y sky130_fd_sc_hd__clkinvlp_4
X_304_ bit_en net55 VGND VGND VPWR VPWR u_controller.reset_ sky130_fd_sc_hd__and2_1
XFILLER_24_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold38 u_spi.bit_cnt\[2\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 u_spi.miso_buffer\[3\] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 u_spi.eoc_sent_high VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_29_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold49 bit_start VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput17 net17 VGND VGND VPWR VPWR dac[8] sky130_fd_sc_hd__buf_2
XFILLER_31_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_120 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_220 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_621_ clknet_3_7__leaf_sys_clk net90 net60 VGND VGND VPWR VPWR clk_cnt\[6\] sky130_fd_sc_hd__dfrtp_1
X_483_ u_spi.miso_buffer\[10\] net31 net26 VGND VGND VPWR VPWR _258_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_14_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_552_ u_spi.pay\[4\] u_spi.pay\[5\] net27 VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__mux2_1
XFILLER_12_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_604_ clknet_3_2__leaf_sys_clk _081_ net52 VGND VGND VPWR VPWR u_spi.miso_buffer\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_535_ _268_ adc_data_out\[0\] net24 VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__mux2_1
XFILLER_27_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_466_ net101 _216_ _243_ _245_ VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__o22a_1
X_397_ net130 _194_ _198_ _154_ VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__o211a_1
XFILLER_32_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout63 net4 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_2
Xfanout52 net54 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_2
Xfanout30 _218_ VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_2
Xfanout41 u_controller.reset_ VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_2
X_320_ adc_data_out\[11\] net136 _155_ VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__mux2_1
XFILLER_13_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_518_ u_controller.counter_reg\[10\] net1 u_controller.dac_reg\[10\] VGND VGND VPWR
+ VPWR _278_ sky130_fd_sc_hd__a21o_1
X_449_ _223_ _232_ VGND VGND VPWR VPWR _233_ sky130_fd_sc_hd__nor2_1
XFILLER_20_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkload5 clknet_3_6__leaf_sys_clk VGND VGND VPWR VPWR clkload5/Y sky130_fd_sc_hd__bufinv_16
XPHY_EDGE_ROW_3_Left_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_303_ u_controller.state\[1\] u_controller.state\[0\] net125 VGND VGND VPWR VPWR
+ _033_ sky130_fd_sc_hd__o21a_1
XFILLER_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold28 u_spi.data_reg\[1\] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 bit_int_en VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 u_spi.data_reg\[6\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_3_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput18 net18 VGND VGND VPWR VPWR dac[9] sky130_fd_sc_hd__buf_2
XFILLER_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_645__66 VGND VGND VPWR VPWR _645__66/HI net66 sky130_fd_sc_hd__conb_1
XFILLER_38_232 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_620_ clknet_3_7__leaf_sys_clk _028_ net61 VGND VGND VPWR VPWR clk_cnt\[5\] sky130_fd_sc_hd__dfrtp_1
X_551_ u_spi.pay\[3\] u_spi.pay\[4\] net27 VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__mux2_1
X_482_ net98 net32 _255_ _257_ VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__o22a_1
XFILLER_12_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_8_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_642__69 VGND VGND VPWR VPWR _642__69/HI net69 sky130_fd_sc_hd__conb_1
XFILLER_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_603_ clknet_3_2__leaf_sys_clk _080_ net51 VGND VGND VPWR VPWR u_spi.miso_buffer\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_465_ net29 _244_ VGND VGND VPWR VPWR _245_ sky130_fd_sc_hd__nor2_1
XFILLER_17_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_534_ u_controller.state\[0\] _264_ u_controller.state\[1\] VGND VGND VPWR VPWR _280_
+ sky130_fd_sc_hd__or3b_2
X_396_ _188_ _197_ VGND VGND VPWR VPWR _198_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout31 _217_ VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_2
XFILLER_13_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout53 net54 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_4
Xfanout42 u_controller.reset_ VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_4
Xfanout64 net1 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_448_ u_spi.data_reg\[2\] net30 _219_ bit_auto VGND VGND VPWR VPWR _232_ sky130_fd_sc_hd__a22oi_1
X_517_ u_controller.dac_reg\[9\] net38 _277_ _149_ VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__o211a_1
X_379_ u_spi.pay\[8\] u_spi.pay\[9\] net27 VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__mux2_1
XFILLER_34_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_302_ net25 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__inv_2
XFILLER_24_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold18 u_spi.miso_buffer\[2\] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 u_spi.data_reg\[5\] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_42_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_83 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput19 net19 VGND VGND VPWR VPWR dac_rst sky130_fd_sc_hd__buf_2
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_550_ u_spi.pay\[3\] u_spi.pay\[2\] _189_ VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__mux2_1
X_481_ net29 _256_ VGND VGND VPWR VPWR _257_ sky130_fd_sc_hd__nor2_1
XFILLER_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_679_ net46 _121_ net42 VGND VGND VPWR VPWR adc_data_out\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_641__70 VGND VGND VPWR VPWR _641__70/HI net70 sky130_fd_sc_hd__conb_1
X_602_ clknet_3_2__leaf_sys_clk _079_ net51 VGND VGND VPWR VPWR u_spi.miso_buffer\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_203 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_464_ u_spi.data_reg\[6\] net30 _219_ bit_clk_sel VGND VGND VPWR VPWR _244_ sky130_fd_sc_hd__a22oi_1
XFILLER_32_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_533_ u_controller.counter_reg\[11\] net19 net38 VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__o21ba_1
X_395_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] u_spi.bit_cnt\[3\] u_spi.bit_cnt\[2\]
+ VGND VGND VPWR VPWR _197_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_10_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout32 _216_ VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_2
Xfanout54 net4 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_2
XFILLER_22_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout43 u_controller.reset_ VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_447_ u_spi.miso_buffer\[1\] net31 net26 VGND VGND VPWR VPWR _231_ sky130_fd_sc_hd__o21a_1
X_378_ u_spi.pay\[7\] u_spi.pay\[8\] net27 VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__mux2_1
X_516_ u_controller.counter_reg\[9\] net64 u_controller.dac_reg\[9\] VGND VGND VPWR
+ VPWR _277_ sky130_fd_sc_hd__a21o_1
XFILLER_11_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_301_ net19 net37 VGND VGND VPWR VPWR _151_ sky130_fd_sc_hd__nor2_1
XFILLER_6_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_4__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_4__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
Xhold19 u_spi.data_reg\[7\] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_480_ u_spi.data_reg\[10\] net30 _219_ ctrl_reg\[10\] VGND VGND VPWR VPWR _256_ sky130_fd_sc_hd__a22oi_2
XFILLER_8_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_678_ net48 _120_ net41 VGND VGND VPWR VPWR adc_data_out\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_5_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_601_ clknet_3_2__leaf_sys_clk _078_ net55 VGND VGND VPWR VPWR u_spi.miso_buffer\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_394_ net128 _196_ _195_ VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__o21a_1
X_463_ u_spi.miso_buffer\[5\] net31 _224_ VGND VGND VPWR VPWR _243_ sky130_fd_sc_hd__o21a_1
X_532_ u_controller.counter_reg\[11\] net38 net25 u_controller.counter_reg\[10\] VGND
+ VGND VPWR VPWR _113_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_10_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout44 net45 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_2
Xfanout55 net4 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
Xfanout33 _157_ VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_2
XFILLER_13_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_515_ u_controller.dac_reg\[8\] net37 _276_ _149_ VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__o211a_1
X_446_ net97 net32 _226_ _230_ VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__o22a_1
XFILLER_13_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_377_ u_spi.pay\[6\] u_spi.pay\[7\] net27 VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__mux2_1
X_300_ u_controller.state\[0\] u_controller.state\[1\] VGND VGND VPWR VPWR _150_ sky130_fd_sc_hd__and2b_1
XFILLER_40_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_429_ u_spi.sck_s1 u_spi.sck_s2 VGND VGND VPWR VPWR _215_ sky130_fd_sc_hd__nand2b_1
Xinput1 comparator VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
XFILLER_19_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_173 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_87 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_677_ net44 _119_ net41 VGND VGND VPWR VPWR adc_data_out\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_600_ clknet_3_2__leaf_sys_clk _077_ net55 VGND VGND VPWR VPWR u_spi.miso_buffer\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_17_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_531_ u_controller.counter_reg\[10\] net37 net25 u_controller.counter_reg\[9\] VGND
+ VGND VPWR VPWR _112_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_42_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_393_ _153_ _188_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] VGND VGND VPWR VPWR _196_
+ sky130_fd_sc_hd__o211a_1
X_462_ net102 net32 _240_ _242_ VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_10_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout34 _155_ VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_4
Xfanout56 net4 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_2
Xfanout45 net48 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_2
XFILLER_22_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_514_ u_controller.counter_reg\[8\] net64 u_controller.dac_reg\[8\] VGND VGND VPWR
+ VPWR _276_ sky130_fd_sc_hd__a21o_1
XFILLER_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_376_ u_spi.state\[0\] _188_ VGND VGND VPWR VPWR _190_ sky130_fd_sc_hd__nand2_1
X_445_ net29 _227_ _228_ _229_ VGND VGND VPWR VPWR _230_ sky130_fd_sc_hd__and4b_1
XFILLER_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_428_ u_spi.pay\[2\] u_spi.bit_cnt\[3\] u_spi.bit_cnt\[4\] u_spi.bit_cnt\[2\] VGND
+ VGND VPWR VPWR _214_ sky130_fd_sc_hd__or4b_1
XPHY_EDGE_ROW_23_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_359_ u_controller.counter_reg\[0\] net35 u_controller.dac_reg\[0\] VGND VGND VPWR
+ VPWR net7 sky130_fd_sc_hd__a21o_1
Xinput2 cs VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_100 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_10_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_114 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_676_ net44 _118_ net40 VGND VGND VPWR VPWR adc_data_out\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_461_ net29 _241_ VGND VGND VPWR VPWR _242_ sky130_fd_sc_hd__nor2_1
XFILLER_27_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_530_ u_controller.counter_reg\[9\] net38 _151_ u_controller.counter_reg\[8\] VGND
+ VGND VPWR VPWR _111_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_42_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_392_ _153_ _194_ VGND VGND VPWR VPWR _195_ sky130_fd_sc_hd__nor2_1
XFILLER_4_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_659_ net47 _101_ net43 VGND VGND VPWR VPWR u_controller.dac_reg\[10\] sky130_fd_sc_hd__dfrtp_1
Xfanout35 net36 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_2
Xfanout24 _280_ VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_4
XFILLER_22_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout57 net63 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_4
Xfanout46 net47 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_444_ u_spi.pay\[0\] u_spi.pay\[1\] bit_start VGND VGND VPWR VPWR _229_ sky130_fd_sc_hd__or3_1
X_513_ u_controller.dac_reg\[7\] net37 _275_ _149_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__o211a_1
X_375_ u_spi.state\[0\] _188_ VGND VGND VPWR VPWR _189_ sky130_fd_sc_hd__and2_2
XFILLER_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_358_ _184_ _185_ _178_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__a21oi_1
X_427_ u_spi.pay\[11\] net28 _213_ net120 VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__a22o_1
X_289_ u_spi.pay\[4\] VGND VGND VPWR VPWR _141_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 mosi VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_186 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_3__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_3__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
X_692_ clknet_3_6__leaf_sys_clk _133_ net63 VGND VGND VPWR VPWR u_spi.pay\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_15_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_675_ net44 _117_ net40 VGND VGND VPWR VPWR adc_data_out\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_391_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] u_spi.bit_cnt\[2\] _188_ VGND VGND VPWR
+ VPWR _194_ sky130_fd_sc_hd__and4_1
X_460_ u_spi.data_reg\[5\] net30 _219_ ctrl_reg\[5\] VGND VGND VPWR VPWR _241_ sky130_fd_sc_hd__a22oi_1
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_589_ clknet_3_1__leaf_sys_clk _066_ net57 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_2
X_658_ net46 _100_ net43 VGND VGND VPWR VPWR u_controller.dac_reg\[9\] sky130_fd_sc_hd__dfrtp_1
Xfanout58 net59 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_4
XFILLER_13_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout36 _150_ VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_2
Xfanout25 _151_ VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_4
Xfanout47 net48 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_2
XFILLER_1_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_374_ _186_ _187_ VGND VGND VPWR VPWR _188_ sky130_fd_sc_hd__nor2_1
XFILLER_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_443_ u_controller.state\[1\] u_controller.state\[0\] _135_ u_spi.pay\[1\] VGND VGND
+ VPWR VPWR _228_ sky130_fd_sc_hd__or4_1
X_512_ u_controller.counter_reg\[7\] net64 u_controller.dac_reg\[7\] VGND VGND VPWR
+ VPWR _275_ sky130_fd_sc_hd__a21o_1
XFILLER_39_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_357_ clk_cnt\[5\] _183_ VGND VGND VPWR VPWR _185_ sky130_fd_sc_hd__nand2_1
X_426_ net49 _148_ net33 VGND VGND VPWR VPWR _213_ sky130_fd_sc_hd__a21o_1
X_288_ u_spi.data_reg\[3\] VGND VGND VPWR VPWR _140_ sky130_fd_sc_hd__inv_2
Xinput4 reset_ VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_39_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_409_ u_spi.pay\[2\] net28 _204_ net133 VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__a22o_1
XFILLER_24_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_691_ clknet_3_4__leaf_sys_clk _132_ net63 VGND VGND VPWR VPWR u_spi.pay\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_674_ net44 _116_ net40 VGND VGND VPWR VPWR adc_data_out\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_36_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_390_ _189_ _192_ _193_ _191_ u_spi.bit_cnt\[1\] VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__a32o_1
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_657_ net46 _099_ net42 VGND VGND VPWR VPWR u_controller.dac_reg\[8\] sky130_fd_sc_hd__dfrtp_1
X_588_ clknet_3_1__leaf_sys_clk _065_ net53 VGND VGND VPWR VPWR bit_auto sky130_fd_sc_hd__dfrtp_1
Xfanout26 _224_ VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_2
Xfanout37 _150_ VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_2
Xfanout59 net63 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_4
XFILLER_13_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout48 net6 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_1_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_511_ u_controller.dac_reg\[6\] net37 _274_ net39 VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__o211a_1
XFILLER_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_373_ u_spi.sck_s2 u_spi.sck_s1 VGND VGND VPWR VPWR _187_ sky130_fd_sc_hd__nand2b_1
XFILLER_9_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_442_ u_spi.pay\[0\] _136_ u_spi.data_reg\[1\] VGND VGND VPWR VPWR _227_ sky130_fd_sc_hd__or3_1
XFILLER_13_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_13_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_356_ clk_cnt\[5\] _183_ VGND VGND VPWR VPWR _184_ sky130_fd_sc_hd__or2_1
X_287_ u_spi.eoc_sent_high VGND VGND VPWR VPWR _139_ sky130_fd_sc_hd__inv_2
X_425_ u_spi.pay\[10\] net28 _212_ net115 VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__a22o_1
XFILLER_5_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput5 sck VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_408_ _138_ net49 net33 VGND VGND VPWR VPWR _204_ sky130_fd_sc_hd__a21o_1
XFILLER_33_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_339_ clk_cnt\[31\] clk_cnt\[30\] clk_cnt\[29\] clk_cnt\[28\] VGND VGND VPWR VPWR
+ _172_ sky130_fd_sc_hd__or4_1
XFILLER_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_690_ clknet_3_4__leaf_sys_clk _131_ net57 VGND VGND VPWR VPWR u_spi.pay\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_22_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_673_ net44 _115_ net40 VGND VGND VPWR VPWR adc_data_out\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_13_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_223 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_587_ clknet_3_3__leaf_sys_clk _064_ net56 VGND VGND VPWR VPWR bit_en sky130_fd_sc_hd__dfrtp_1
X_656_ net46 _098_ net42 VGND VGND VPWR VPWR u_controller.dac_reg\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_31_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout27 _190_ VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_4
Xfanout49 u_spi.cmd\[1\] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_4
Xfanout38 _150_ VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_2
X_441_ u_spi.miso_buffer\[0\] net31 _224_ VGND VGND VPWR VPWR _226_ sky130_fd_sc_hd__o21a_1
X_510_ u_controller.counter_reg\[6\] net64 u_controller.dac_reg\[6\] VGND VGND VPWR
+ VPWR _274_ sky130_fd_sc_hd__a21o_1
X_372_ net2 u_spi.state\[1\] VGND VGND VPWR VPWR _186_ sky130_fd_sc_hd__or2_1
XFILLER_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_639_ clknet_3_5__leaf_sys_clk net72 net58 VGND VGND VPWR VPWR clk_cnt\[24\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_17_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_424_ net49 _147_ net33 VGND VGND VPWR VPWR _212_ sky130_fd_sc_hd__a21o_1
X_286_ u_spi.pay\[2\] VGND VGND VPWR VPWR _138_ sky130_fd_sc_hd__inv_2
X_355_ _178_ _182_ _183_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_1_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Left_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_407_ u_spi.pay\[0\] net28 _203_ bit_en VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_338_ clk_cnt\[11\] clk_cnt\[10\] clk_cnt\[9\] clk_cnt\[8\] VGND VGND VPWR VPWR _171_
+ sky130_fd_sc_hd__or4_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_629__82 VGND VGND VPWR VPWR _629__82/HI net82 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_39_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_29_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_672_ net47 _114_ net43 VGND VGND VPWR VPWR u_controller.counter_reg\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_626__85 VGND VGND VPWR VPWR _626__85/HI net85 sky130_fd_sc_hd__conb_1
XFILLER_19_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_2__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_2__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_8_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_235 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_158 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_623__88 VGND VGND VPWR VPWR _623__88/HI net88 sky130_fd_sc_hd__conb_1
X_655_ net45 _097_ net42 VGND VGND VPWR VPWR u_controller.dac_reg\[6\] sky130_fd_sc_hd__dfrtp_1
X_586_ clknet_3_6__leaf_sys_clk _037_ net60 VGND VGND VPWR VPWR u_spi.data_reg\[11\]
+ sky130_fd_sc_hd__dfrtp_1
Xfanout28 _158_ VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_2
Xfanout39 _149_ VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_4
X_440_ net95 net31 _221_ _225_ VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__a22o_1
X_371_ eoc_flag bit_int_en VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__and2_1
X_638_ clknet_3_5__leaf_sys_clk net73 net58 VGND VGND VPWR VPWR clk_cnt\[23\] sky130_fd_sc_hd__dfrtp_1
X_569_ clknet_3_0__leaf_sys_clk _060_ net51 VGND VGND VPWR VPWR u_spi.bit_cnt\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_24_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_423_ u_spi.pay\[9\] net28 _211_ net103 VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__a22o_1
X_354_ clk_cnt\[3\] clk_cnt\[4\] _180_ VGND VGND VPWR VPWR _183_ sky130_fd_sc_hd__nand3_1
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_285_ u_spi.pay\[3\] VGND VGND VPWR VPWR _137_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_1_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_337_ clk_cnt\[5\] clk_cnt\[4\] clk_cnt\[7\] clk_cnt\[6\] VGND VGND VPWR VPWR _170_
+ sky130_fd_sc_hd__a211o_1
X_406_ _135_ net50 _157_ VGND VGND VPWR VPWR _203_ sky130_fd_sc_hd__a21o_1
XFILLER_25_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_671_ net47 _113_ net43 VGND VGND VPWR VPWR u_controller.counter_reg\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_654_ net45 _096_ net41 VGND VGND VPWR VPWR u_controller.dac_reg\[5\] sky130_fd_sc_hd__dfrtp_1
X_585_ clknet_3_6__leaf_sys_clk _036_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_31_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xfanout29 _223_ VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_32_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_370_ u_controller.counter_reg\[11\] net38 u_controller.dac_reg\[11\] VGND VGND VPWR
+ VPWR net9 sky130_fd_sc_hd__a21o_1
X_637_ clknet_3_5__leaf_sys_clk net74 net58 VGND VGND VPWR VPWR clk_cnt\[22\] sky130_fd_sc_hd__dfrtp_1
X_568_ clknet_3_0__leaf_sys_clk _059_ net51 VGND VGND VPWR VPWR u_spi.bit_cnt\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_499_ u_controller.dac_reg\[0\] net35 _268_ net39 VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__o211a_1
XFILLER_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_284_ u_spi.pay\[1\] VGND VGND VPWR VPWR _136_ sky130_fd_sc_hd__inv_2
X_422_ net49 _146_ net33 VGND VGND VPWR VPWR _211_ sky130_fd_sc_hd__a21o_1
X_353_ clk_cnt\[3\] _180_ clk_cnt\[4\] VGND VGND VPWR VPWR _182_ sky130_fd_sc_hd__a21o_1
XFILLER_5_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_1_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_336_ clk_cnt\[15\] clk_cnt\[14\] clk_cnt\[13\] clk_cnt\[12\] VGND VGND VPWR VPWR
+ _169_ sky130_fd_sc_hd__or4_1
X_405_ _152_ _202_ net138 VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__o21ba_1
XFILLER_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_638__73 VGND VGND VPWR VPWR _638__73/HI net73 sky130_fd_sc_hd__conb_1
XFILLER_14_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_319_ adc_data_out\[10\] net137 _155_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_39_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_635__76 VGND VGND VPWR VPWR _635__76/HI net76 sky130_fd_sc_hd__conb_1
X_670_ net47 _112_ net43 VGND VGND VPWR VPWR u_controller.counter_reg\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_632__79 VGND VGND VPWR VPWR _632__79/HI net79 sky130_fd_sc_hd__conb_1
XFILLER_25_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_653_ net44 _095_ net41 VGND VGND VPWR VPWR u_controller.dac_reg\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_584_ clknet_3_6__leaf_sys_clk _046_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_31_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_636_ clknet_3_5__leaf_sys_clk net75 net58 VGND VGND VPWR VPWR clk_cnt\[21\] sky130_fd_sc_hd__dfrtp_1
X_567_ clknet_3_0__leaf_sys_clk _058_ net51 VGND VGND VPWR VPWR u_spi.bit_cnt\[2\]
+ sky130_fd_sc_hd__dfrtp_1
X_498_ u_controller.counter_reg\[0\] net64 u_controller.dac_reg\[0\] VGND VGND VPWR
+ VPWR _268_ sky130_fd_sc_hd__a21o_1
XFILLER_40_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_421_ u_spi.pay\[8\] net28 _210_ net93 VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__a22o_1
X_283_ u_spi.pay\[0\] VGND VGND VPWR VPWR _135_ sky130_fd_sc_hd__inv_2
X_352_ _178_ _181_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_1_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_619_ clknet_3_7__leaf_sys_clk _027_ net61 VGND VGND VPWR VPWR clk_cnt\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_27_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_38 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_404_ _156_ _200_ _201_ eoc_flag VGND VGND VPWR VPWR _202_ sky130_fd_sc_hd__o31a_1
XFILLER_41_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_335_ _165_ _166_ _167_ VGND VGND VPWR VPWR _168_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_6_Left_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_318_ adc_data_out\[9\] net121 net34 VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__mux2_1
XFILLER_42_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_631__80 VGND VGND VPWR VPWR _631__80/HI net80 sky130_fd_sc_hd__conb_1
XPHY_EDGE_ROW_9_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_652_ net44 _094_ net40 VGND VGND VPWR VPWR u_controller.dac_reg\[3\] sky130_fd_sc_hd__dfrtp_1
X_583_ clknet_3_6__leaf_sys_clk _045_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_183 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold1 u_spi.eoc_s1 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_35_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_1__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_1__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
X_635_ clknet_3_5__leaf_sys_clk net76 net58 VGND VGND VPWR VPWR clk_cnt\[20\] sky130_fd_sc_hd__dfrtp_1
X_566_ clknet_3_0__leaf_sys_clk _057_ net53 VGND VGND VPWR VPWR u_spi.bit_cnt\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_497_ _177_ _266_ _267_ VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__and3_1
XFILLER_5_86 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_420_ net49 _145_ net33 VGND VGND VPWR VPWR _210_ sky130_fd_sc_hd__a21o_1
X_351_ clk_cnt\[3\] _180_ VGND VGND VPWR VPWR _181_ sky130_fd_sc_hd__xnor2_1
X_282_ u_spi.state\[0\] VGND VGND VPWR VPWR _134_ sky130_fd_sc_hd__inv_2
XFILLER_39_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_549_ u_spi.pay\[1\] u_spi.pay\[2\] net27 VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__mux2_1
X_618_ clknet_3_7__leaf_sys_clk _026_ net61 VGND VGND VPWR VPWR clk_cnt\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_35_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_403_ u_spi.state\[0\] net49 u_spi.cmd\[0\] u_spi.state\[1\] VGND VGND VPWR VPWR
+ _201_ sky130_fd_sc_hd__or4b_1
X_334_ clk_cnt\[27\] clk_cnt\[26\] clk_cnt\[25\] clk_cnt\[24\] VGND VGND VPWR VPWR
+ _167_ sky130_fd_sc_hd__or4_1
XPHY_EDGE_ROW_38_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_317_ adc_data_out\[8\] net126 net34 VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__mux2_1
X_644__67 VGND VGND VPWR VPWR _644__67/HI net67 sky130_fd_sc_hd__conb_1
XFILLER_35_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_720_ u_spi.miso_buffer\[11\] _281_ VGND VGND VPWR VPWR miso sky130_fd_sc_hd__ebufn_8
X_651_ net44 _093_ net40 VGND VGND VPWR VPWR u_controller.dac_reg\[2\] sky130_fd_sc_hd__dfrtp_1
X_582_ clknet_3_6__leaf_sys_clk _044_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold2 u_spi.sck_s1 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_634_ clknet_3_5__leaf_sys_clk net77 net59 VGND VGND VPWR VPWR clk_cnt\[19\] sky130_fd_sc_hd__dfrtp_1
X_565_ clknet_3_1__leaf_sys_clk _056_ net53 VGND VGND VPWR VPWR u_spi.bit_cnt\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_496_ _164_ _176_ net47 VGND VGND VPWR VPWR _267_ sky130_fd_sc_hd__o21ai_1
XFILLER_5_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_350_ _178_ _180_ _174_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__nor3b_1
XFILLER_14_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_617_ clknet_3_7__leaf_sys_clk _023_ net61 VGND VGND VPWR VPWR clk_cnt\[2\] sky130_fd_sc_hd__dfrtp_1
X_479_ u_spi.miso_buffer\[9\] net31 net26 VGND VGND VPWR VPWR _255_ sky130_fd_sc_hd__o21a_1
X_548_ u_spi.pay\[0\] u_spi.pay\[1\] net27 VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__mux2_1
XFILLER_27_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_333_ clk_cnt\[23\] clk_cnt\[22\] clk_cnt\[21\] clk_cnt\[20\] VGND VGND VPWR VPWR
+ _166_ sky130_fd_sc_hd__or4_1
X_402_ u_spi.addr\[1\] _139_ u_spi.addr\[0\] VGND VGND VPWR VPWR _200_ sky130_fd_sc_hd__o21a_1
XFILLER_26_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_42 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_316_ adc_data_out\[7\] net109 net34 VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__mux2_1
XFILLER_28_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_4_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_640__71 VGND VGND VPWR VPWR _640__71/HI net71 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_35_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_650_ net44 _092_ net40 VGND VGND VPWR VPWR u_controller.dac_reg\[1\] sky130_fd_sc_hd__dfrtp_1
X_581_ clknet_3_6__leaf_sys_clk _043_ net62 VGND VGND VPWR VPWR u_spi.data_reg\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_41_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold3 ctrl_reg\[8\] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_633_ clknet_3_5__leaf_sys_clk net78 net58 VGND VGND VPWR VPWR clk_cnt\[18\] sky130_fd_sc_hd__dfrtp_1
X_564_ clknet_3_0__leaf_sys_clk net5 net51 VGND VGND VPWR VPWR u_spi.sck_s1 sky130_fd_sc_hd__dfrtp_1
X_495_ net47 _164_ _176_ VGND VGND VPWR VPWR _266_ sky130_fd_sc_hd__or3_1
XFILLER_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_616_ clknet_3_7__leaf_sys_clk _012_ net61 VGND VGND VPWR VPWR clk_cnt\[1\] sky130_fd_sc_hd__dfrtp_1
X_547_ u_spi.pay\[0\] net3 _189_ VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__mux2_1
X_478_ net105 net32 _252_ _254_ VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__o22a_1
X_401_ _186_ _199_ VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__and2b_1
XFILLER_41_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_332_ clk_cnt\[19\] clk_cnt\[18\] clk_cnt\[17\] clk_cnt\[16\] VGND VGND VPWR VPWR
+ _165_ sky130_fd_sc_hd__or4_1
XFILLER_2_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_19_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_315_ adc_data_out\[6\] net107 net34 VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__mux2_1
XFILLER_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_40_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_580_ clknet_3_3__leaf_sys_clk _042_ net56 VGND VGND VPWR VPWR u_spi.data_reg\[5\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_16_238 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold4 u_spi.miso_buffer\[7\] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_22_208 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_563_ clknet_3_1__leaf_sys_clk _055_ net53 VGND VGND VPWR VPWR u_spi.cmd\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_632_ clknet_3_5__leaf_sys_clk net79 net58 VGND VGND VPWR VPWR clk_cnt\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_494_ net117 eoc_flag _265_ VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_615_ clknet_3_7__leaf_sys_clk _001_ net60 VGND VGND VPWR VPWR clk_cnt\[0\] sky130_fd_sc_hd__dfrtp_1
X_546_ _279_ adc_data_out\[11\] _280_ VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__mux2_1
X_477_ net29 _253_ VGND VGND VPWR VPWR _254_ sky130_fd_sc_hd__nor2_1
Xclkbuf_3_0__f_sys_clk clknet_0_sys_clk VGND VGND VPWR VPWR clknet_3_0__leaf_sys_clk
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_35_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_400_ net112 _154_ _198_ _062_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__a31o_1
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_331_ clk_cnt\[5\] _163_ bit_clk_sel VGND VGND VPWR VPWR _164_ sky130_fd_sc_hd__o21a_1
XFILLER_41_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_529_ u_controller.counter_reg\[8\] net37 _151_ u_controller.counter_reg\[7\] VGND
+ VGND VPWR VPWR _110_ sky130_fd_sc_hd__a22o_1
X_314_ adc_data_out\[5\] net119 net34 VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_26_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold5 u_spi.miso_buffer\[0\] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_29_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_493_ _135_ u_spi.pay\[1\] net26 VGND VGND VPWR VPWR _265_ sky130_fd_sc_hd__nor3_1
X_562_ clknet_3_1__leaf_sys_clk _054_ net53 VGND VGND VPWR VPWR u_spi.cmd\[0\] sky130_fd_sc_hd__dfrtp_2
X_631_ clknet_3_5__leaf_sys_clk net80 net58 VGND VGND VPWR VPWR clk_cnt\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_8_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_614_ clknet_3_3__leaf_sys_clk _033_ net56 VGND VGND VPWR VPWR start_clear_req sky130_fd_sc_hd__dfrtp_1
X_476_ u_spi.data_reg\[9\] net30 _219_ ctrl_reg\[9\] VGND VGND VPWR VPWR _253_ sky130_fd_sc_hd__a22oi_1
X_545_ _278_ adc_data_out\[10\] _280_ VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__mux2_1
XFILLER_25_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_330_ clk_cnt\[3\] _162_ clk_cnt\[4\] VGND VGND VPWR VPWR _163_ sky130_fd_sc_hd__o21a_1
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_142 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_459_ u_spi.miso_buffer\[4\] net31 net26 VGND VGND VPWR VPWR _240_ sky130_fd_sc_hd__o21a_1
X_528_ u_controller.counter_reg\[7\] net37 net25 u_controller.counter_reg\[6\] VGND
+ VGND VPWR VPWR _109_ sky130_fd_sc_hd__a22o_1
XFILLER_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_1_Left_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_313_ adc_data_out\[4\] net114 net34 VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__mux2_1
XFILLER_37_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 u_spi.miso_buffer\[4\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_630_ clknet_3_7__leaf_sys_clk net81 net60 VGND VGND VPWR VPWR clk_cnt\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_561_ clknet_3_1__leaf_sys_clk _053_ net53 VGND VGND VPWR VPWR u_spi.addr\[1\] sky130_fd_sc_hd__dfrtp_1
X_492_ adc_en_n _149_ net25 VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_30_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_613_ clknet_3_3__leaf_sys_clk _000_ net56 VGND VGND VPWR VPWR adc_en_n sky130_fd_sc_hd__dfstp_1
X_475_ u_spi.miso_buffer\[8\] net31 net26 VGND VGND VPWR VPWR _252_ sky130_fd_sc_hd__o21a_1
X_544_ _277_ adc_data_out\[9\] net24 VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__mux2_1
XFILLER_4_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_527_ u_controller.counter_reg\[6\] net36 _151_ u_controller.counter_reg\[5\] VGND
+ VGND VPWR VPWR _108_ sky130_fd_sc_hd__a22o_1
X_458_ net96 net32 _237_ _239_ VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__o22a_1
X_389_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] VGND VGND VPWR VPWR _193_ sky130_fd_sc_hd__nand2_1
XFILLER_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_312_ adc_data_out\[3\] net127 net34 VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_77 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold7 u_spi.miso_buffer\[1\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_40_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_560_ clknet_3_1__leaf_sys_clk _052_ net53 VGND VGND VPWR VPWR u_spi.addr\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_12_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_491_ net37 _264_ adc_en_n net19 VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__a211oi_1
XFILLER_8_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_689_ clknet_3_0__leaf_sys_clk _130_ net51 VGND VGND VPWR VPWR u_spi.pay\[3\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_612_ clknet_3_3__leaf_sys_clk net91 net56 VGND VGND VPWR VPWR u_spi.eoc_s2 sky130_fd_sc_hd__dfrtp_1
X_543_ _276_ adc_data_out\[8\] net24 VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__mux2_1
X_474_ net99 net32 _249_ _251_ VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__o22a_1
XFILLER_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_526_ u_controller.counter_reg\[5\] net36 net25 u_controller.counter_reg\[4\] VGND
+ VGND VPWR VPWR _107_ sky130_fd_sc_hd__a22o_1
XFILLER_17_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_103 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_457_ net29 _238_ VGND VGND VPWR VPWR _239_ sky130_fd_sc_hd__nor2_1
X_388_ u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] VGND VGND VPWR VPWR _192_ sky130_fd_sc_hd__or2_1
XFILLER_23_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_311_ adc_data_out\[2\] net113 net34 VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_509_ u_controller.dac_reg\[5\] net36 _273_ net39 VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_15_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_9_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_38_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_89 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold8 u_spi.miso_buffer\[10\] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_40_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_490_ _261_ _262_ _263_ VGND VGND VPWR VPWR _264_ sky130_fd_sc_hd__or3_1
XFILLER_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_688_ clknet_3_1__leaf_sys_clk _129_ net54 VGND VGND VPWR VPWR u_spi.pay\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_473_ net29 _250_ VGND VGND VPWR VPWR _251_ sky130_fd_sc_hd__nor2_1
X_611_ net45 _088_ net42 VGND VGND VPWR VPWR u_controller.state\[1\] sky130_fd_sc_hd__dfrtp_1
X_542_ _275_ adc_data_out\[7\] net24 VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__mux2_1
XFILLER_41_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_525_ u_controller.counter_reg\[4\] net35 net25 u_controller.counter_reg\[3\] VGND
+ VGND VPWR VPWR _106_ sky130_fd_sc_hd__a22o_1
X_456_ u_spi.data_reg\[4\] net30 _219_ bit_int_en VGND VGND VPWR VPWR _238_ sky130_fd_sc_hd__a22oi_1
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_115 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_387_ _189_ _191_ u_spi.bit_cnt\[0\] VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_18_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_310_ adc_data_out\[1\] net118 net34 VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__mux2_1
XFILLER_22_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_439_ net26 VGND VGND VPWR VPWR _225_ sky130_fd_sc_hd__inv_2
X_508_ u_controller.counter_reg\[5\] net64 u_controller.dac_reg\[5\] VGND VGND VPWR
+ VPWR _273_ sky130_fd_sc_hd__a21o_1
XFILLER_9_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_5_Left_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_3_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold9 u_spi.miso_buffer\[8\] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_15_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_8_Left_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_687_ clknet_3_1__leaf_sys_clk _128_ net54 VGND VGND VPWR VPWR u_spi.pay\[1\] sky130_fd_sc_hd__dfrtp_4
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_610_ net45 _087_ net42 VGND VGND VPWR VPWR u_controller.state\[0\] sky130_fd_sc_hd__dfrtp_2
XPHY_EDGE_ROW_34_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_541_ _274_ adc_data_out\[6\] net24 VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__mux2_1
X_472_ u_spi.data_reg\[8\] net30 _219_ ctrl_reg\[8\] VGND VGND VPWR VPWR _250_ sky130_fd_sc_hd__a22oi_1
XFILLER_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_524_ u_controller.counter_reg\[3\] net35 net25 u_controller.counter_reg\[2\] VGND
+ VGND VPWR VPWR _105_ sky130_fd_sc_hd__a22o_1
X_455_ u_spi.miso_buffer\[3\] _217_ net26 VGND VGND VPWR VPWR _237_ sky130_fd_sc_hd__o21a_1
X_386_ _153_ _188_ VGND VGND VPWR VPWR _191_ sky130_fd_sc_hd__nor2_1
XFILLER_32_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_507_ u_controller.dac_reg\[4\] net36 _272_ net39 VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__o211a_1
X_438_ _134_ u_spi.state\[1\] net29 VGND VGND VPWR VPWR _224_ sky130_fd_sc_hd__or3_2
XPHY_EDGE_ROW_21_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_369_ u_controller.counter_reg\[10\] net38 u_controller.dac_reg\[10\] VGND VGND VPWR
+ VPWR net8 sky130_fd_sc_hd__a21o_1
X_628__83 VGND VGND VPWR VPWR _628__83/HI net83 sky130_fd_sc_hd__conb_1
XFILLER_9_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_625__86 VGND VGND VPWR VPWR _625__86/HI net86 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_3_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_622__89 VGND VGND VPWR VPWR _622__89/HI net89 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_40_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_686_ clknet_3_0__leaf_sys_clk _127_ net52 VGND VGND VPWR VPWR u_spi.pay\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_7_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_111 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_0_sys_clk sys_clk VGND VGND VPWR VPWR clknet_0_sys_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_38_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_540_ _273_ adc_data_out\[5\] net24 VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__mux2_1
XFILLER_29_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_471_ u_spi.miso_buffer\[7\] net31 net26 VGND VGND VPWR VPWR _249_ sky130_fd_sc_hd__o21a_1
X_669_ net46 _111_ net43 VGND VGND VPWR VPWR u_controller.counter_reg\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_29_90 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_523_ u_controller.counter_reg\[2\] net35 net25 u_controller.counter_reg\[1\] VGND
+ VGND VPWR VPWR _104_ sky130_fd_sc_hd__a22o_1
XFILLER_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_454_ net106 net32 _234_ _236_ VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__o22a_1
X_385_ net49 u_spi.cmd\[0\] _189_ VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__mux2_1
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_506_ u_controller.counter_reg\[4\] net64 u_controller.dac_reg\[4\] VGND VGND VPWR
+ VPWR _272_ sky130_fd_sc_hd__a21o_1
X_437_ net2 _214_ _215_ _222_ VGND VGND VPWR VPWR _223_ sky130_fd_sc_hd__or4_2
XFILLER_13_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_299_ net39 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__inv_2
X_368_ u_controller.counter_reg\[9\] net38 u_controller.dac_reg\[9\] VGND VGND VPWR
+ VPWR net18 sky130_fd_sc_hd__a21o_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_621__90 VGND VGND VPWR VPWR _621__90/HI net90 sky130_fd_sc_hd__conb_1
XFILLER_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_685_ clknet_3_3__leaf_sys_clk _034_ net54 VGND VGND VPWR VPWR bit_start sky130_fd_sc_hd__dfrtp_1
XFILLER_38_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_470_ net94 net32 _246_ _248_ VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__o22a_1
X_599_ clknet_3_2__leaf_sys_clk _076_ net55 VGND VGND VPWR VPWR u_spi.miso_buffer\[1\]
+ sky130_fd_sc_hd__dfrtp_1
X_668_ net46 _110_ net42 VGND VGND VPWR VPWR u_controller.counter_reg\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_41_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_453_ _140_ net30 _223_ _235_ VGND VGND VPWR VPWR _236_ sky130_fd_sc_hd__a211oi_1
X_522_ u_controller.counter_reg\[1\] net35 net25 u_controller.counter_reg\[0\] VGND
+ VGND VPWR VPWR _103_ sky130_fd_sc_hd__a22o_1
X_384_ u_spi.cmd\[0\] net132 _189_ VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_27_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_637__74 VGND VGND VPWR VPWR _637__74/HI net74 sky130_fd_sc_hd__conb_1
XFILLER_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_436_ u_spi.pay\[3\] u_spi.bit_cnt\[1\] u_spi.bit_cnt\[0\] VGND VGND VPWR VPWR _222_
+ sky130_fd_sc_hd__or3_1
X_505_ u_controller.dac_reg\[3\] net35 _271_ net39 VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__o211a_1
XFILLER_26_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_298_ u_controller.state\[1\] u_controller.state\[0\] VGND VGND VPWR VPWR _149_ sky130_fd_sc_hd__nand2b_2
X_367_ u_controller.counter_reg\[8\] net37 u_controller.dac_reg\[8\] VGND VGND VPWR
+ VPWR net17 sky130_fd_sc_hd__a21o_1
XFILLER_36_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_634__77 VGND VGND VPWR VPWR _634__77/HI net77 sky130_fd_sc_hd__conb_1
XTAP_TAPCELL_ROW_6_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_419_ u_spi.pay\[7\] _158_ _209_ net100 VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__a22o_1
XFILLER_23_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_684_ net47 _126_ net43 VGND VGND VPWR VPWR adc_data_out\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_7_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_598_ clknet_3_3__leaf_sys_clk _075_ net56 VGND VGND VPWR VPWR u_spi.miso_buffer\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_667_ net48 _109_ net42 VGND VGND VPWR VPWR u_controller.counter_reg\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_41_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_452_ _135_ net23 u_spi.pay\[1\] VGND VGND VPWR VPWR _235_ sky130_fd_sc_hd__a21oi_1
X_383_ net131 net132 net27 VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_27_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_521_ u_controller.dac_reg\[11\] net38 _279_ net39 VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__o211a_1
X_719_ net19 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
XFILLER_36_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_504_ u_controller.counter_reg\[3\] net64 u_controller.dac_reg\[3\] VGND VGND VPWR
+ VPWR _271_ sky130_fd_sc_hd__a21o_1
X_435_ u_spi.data_reg\[0\] net30 _219_ bit_en _220_ VGND VGND VPWR VPWR _221_ sky130_fd_sc_hd__a221o_1
X_366_ u_controller.counter_reg\[7\] net37 u_controller.dac_reg\[7\] VGND VGND VPWR
+ VPWR net16 sky130_fd_sc_hd__a21o_1
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_297_ u_controller.state\[1\] u_controller.state\[0\] VGND VGND VPWR VPWR adc_ack
+ sky130_fd_sc_hd__and2_1
XFILLER_36_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_418_ net50 _144_ _157_ VGND VGND VPWR VPWR _209_ sky130_fd_sc_hd__a21o_1
X_349_ clk_cnt\[1\] clk_cnt\[0\] clk_cnt\[2\] VGND VGND VPWR VPWR _180_ sky130_fd_sc_hd__and3_1
X_630__81 VGND VGND VPWR VPWR _630__81/HI net81 sky130_fd_sc_hd__conb_1
XFILLER_15_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_683_ net46 _125_ net43 VGND VGND VPWR VPWR adc_data_out\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_666_ net48 _108_ net41 VGND VGND VPWR VPWR u_controller.counter_reg\[5\] sky130_fd_sc_hd__dfrtp_1
X_597_ clknet_3_4__leaf_sys_clk _074_ net57 VGND VGND VPWR VPWR ctrl_reg\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_520_ u_controller.counter_reg\[11\] net1 u_controller.dac_reg\[11\] VGND VGND VPWR
+ VPWR _279_ sky130_fd_sc_hd__a21o_1
X_451_ u_spi.miso_buffer\[2\] _217_ net26 VGND VGND VPWR VPWR _234_ sky130_fd_sc_hd__o21a_1
X_382_ net131 u_spi.pay\[11\] _189_ VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__mux2_1
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_649_ net44 _091_ net40 VGND VGND VPWR VPWR u_controller.dac_reg\[0\] sky130_fd_sc_hd__dfrtp_1
X_646__65 VGND VGND VPWR VPWR _646__65/HI net65 sky130_fd_sc_hd__conb_1
XFILLER_39_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_503_ u_controller.dac_reg\[2\] net35 _270_ net39 VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__o211a_1
X_434_ u_spi.pay\[0\] _136_ eoc_flag VGND VGND VPWR VPWR _220_ sky130_fd_sc_hd__and3_1
XFILLER_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_365_ u_controller.counter_reg\[6\] net36 u_controller.dac_reg\[6\] VGND VGND VPWR
+ VPWR net15 sky130_fd_sc_hd__a21o_1
X_296_ u_spi.pay\[11\] VGND VGND VPWR VPWR _148_ sky130_fd_sc_hd__inv_2
XFILLER_26_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_643__68 VGND VGND VPWR VPWR _643__68/HI net68 sky130_fd_sc_hd__conb_1
XFILLER_36_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Left_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_348_ _178_ _179_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_417_ u_spi.pay\[6\] _158_ _208_ net134 VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__a22o_1
XFILLER_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_682_ net46 _124_ net43 VGND VGND VPWR VPWR adc_data_out\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_11_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_665_ net45 _107_ net41 VGND VGND VPWR VPWR u_controller.counter_reg\[4\] sky130_fd_sc_hd__dfrtp_1
X_596_ clknet_3_4__leaf_sys_clk net116 net57 VGND VGND VPWR VPWR ctrl_reg\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_450_ net108 net32 _231_ _233_ VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__o22a_1
X_381_ u_spi.pay\[10\] u_spi.pay\[11\] net27 VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__mux2_1
XFILLER_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_648_ clknet_3_7__leaf_sys_clk _090_ net61 VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__dfrtp_1
X_579_ clknet_3_3__leaf_sys_clk _041_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_16_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_502_ u_controller.counter_reg\[2\] net64 u_controller.dac_reg\[2\] VGND VGND VPWR
+ VPWR _270_ sky130_fd_sc_hd__a21o_1
X_433_ u_spi.pay\[0\] u_spi.pay\[1\] VGND VGND VPWR VPWR _219_ sky130_fd_sc_hd__nor2_4
X_364_ u_controller.counter_reg\[5\] net36 u_controller.dac_reg\[5\] VGND VGND VPWR
+ VPWR net14 sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_23_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_295_ u_spi.pay\[10\] VGND VGND VPWR VPWR _147_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_6_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_27_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_416_ net50 _143_ _157_ VGND VGND VPWR VPWR _208_ sky130_fd_sc_hd__a21o_1
X_347_ clk_cnt\[1\] clk_cnt\[0\] VGND VGND VPWR VPWR _179_ sky130_fd_sc_hd__xnor2_1
XFILLER_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_219 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_18_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_681_ net46 _123_ net42 VGND VGND VPWR VPWR adc_data_out\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_38_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold40 u_spi.bit_cnt\[3\] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_20_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_664_ net45 _106_ net40 VGND VGND VPWR VPWR u_controller.counter_reg\[3\] sky130_fd_sc_hd__dfrtp_1
X_595_ clknet_3_4__leaf_sys_clk net104 net57 VGND VGND VPWR VPWR ctrl_reg\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_6_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_119 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_380_ u_spi.pay\[9\] u_spi.pay\[10\] net27 VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__mux2_1
Xoutput6 net47 VGND VGND VPWR VPWR adc_clk_out sky130_fd_sc_hd__buf_2
X_578_ clknet_3_2__leaf_sys_clk _040_ net55 VGND VGND VPWR VPWR u_spi.data_reg\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_647_ clknet_3_1__leaf_sys_clk _089_ net53 VGND VGND VPWR VPWR u_spi.eoc_sent_high
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_16_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
.ends
